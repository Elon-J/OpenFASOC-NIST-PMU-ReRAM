* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt sky130_fd_pr__pfet_01v8_UGG56J a_n73_n10000# a_15_n10000# w_n211_n10219# a_n33_n10097#
X0 a_15_n10000# a_n33_n10097# a_n73_n10000# w_n211_n10219# sky130_fd_pr__pfet_01v8 ad=3.6e+13p pd=2.0072e+08u as=2.9e+13p ps=2.0058e+08u w=1e+08u l=150000u
.ends

.subckt BIG_PMOS
XBIG_PMOS m1_12219_232# m1_12219_n1955# li_266_352# m1_36_n9955# sky130_fd_pr__pfet_01v8_UGG56J
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_5RKW4M m4_n3351_n3100# c2_n3251_n3000#
X0 c2_n3251_n3000# m4_n3351_n3100# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
.ends

.subckt x2fF_decap sky130_fd_pr__cap_mim_m3_2_5RKW4M_0/c2_n3251_n3000# sky130_fd_pr__cap_mim_m3_2_5RKW4M_0/m4_n3351_n3100#
Xsky130_fd_pr__cap_mim_m3_2_5RKW4M_0 sky130_fd_pr__cap_mim_m3_2_5RKW4M_0/m4_n3351_n3100#
+ sky130_fd_pr__cap_mim_m3_2_5RKW4M_0/c2_n3251_n3000# sky130_fd_pr__cap_mim_m3_2_5RKW4M
.ends

.subckt sky130_fd_sc_hd__nand2_1 VGND VPWR Y B A VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_1 VGND VPWR Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfstp_1 VPWR VGND D Q SET_B CLK VNB VPB
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=9.868e+11p pd=1.019e+07u as=1.341e+11p ps=1.5e+06u w=420000u l=150000u
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=9.66e+10p pd=1.3e+06u as=1.3171e+12p ps=1.335e+07u w=420000u l=150000u
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.44e+11p ps=1.52e+06u w=360000u l=150000u
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.87e+11p ps=1.93e+06u w=360000u l=150000u
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.499e+11p pd=2.35e+06u as=0p ps=0u w=840000u l=150000u
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.386e+11p ps=1.5e+06u w=420000u l=150000u
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.89e+11p pd=1.74e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=9.66e+10p pd=1.3e+06u as=0p ps=0u w=420000u l=150000u
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.184e+11p pd=2.2e+06u as=0p ps=0u w=840000u l=150000u
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_1 VGND VPWR B Y A VNB VPB
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 VGND VPWR X A VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=9.1e+11p pd=7.82e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=3.801e+11p pd=4.33e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.6e+11p pd=5.12e+06u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_2 VGND VPWR Y A B VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=7.9e+11p pd=7.58e+06u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 VGND VPWR A X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_16 VGND VPWR A X VNB VPB
X0 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.093e+12p pd=2.204e+07u as=5.265e+11p ps=5.52e+06u w=650000u l=150000u
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.16e+12p pd=2.032e+07u as=3.22e+12p ps=3.044e+07u w=1e+06u l=150000u
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.404e+12p ps=1.472e+07u w=650000u l=150000u
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.1e+11p pd=7.62e+06u as=0p ps=0u w=1e+06u l=150000u
X8 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X32 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X35 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X40 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X41 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X42 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X43 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_2 VPWR VGND X A VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=5.63e+11p pd=5.18e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=3.6625e+11p ps=3.78e+06u w=650000u l=150000u
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2 VPWR VGND A Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_1 VGND VPWR Y A C B VNB VPB
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.9e+11p pd=5.18e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfstp_2 VPWR VGND Q D SET_B CLK VNB VPB
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=1.1373e+12p pd=1.19e+07u as=1.341e+11p ps=1.5e+06u w=420000u l=150000u
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=1.5449e+12p ps=1.575e+07u w=420000u l=150000u
X2 a_1136_413# a_193_47# a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X3 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X4 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.44e+11p ps=1.52e+06u w=360000u l=150000u
X5 a_1228_47# a_27_47# a_1028_413# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.47e+11p ps=1.54e+06u w=420000u l=150000u
X6 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X7 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.87e+11p ps=1.93e+06u w=360000u l=150000u
X8 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X9 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.499e+11p pd=2.35e+06u as=0p ps=0u w=840000u l=150000u
X10 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VPWR a_1602_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X12 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.89e+11p pd=1.74e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X13 VGND a_1028_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X14 VGND a_1602_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X15 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_1028_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 VPWR a_1028_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X20 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_1028_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VPWR a_1178_261# a_1136_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X25 a_1178_261# a_1028_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.226e+11p pd=2.21e+06u as=0p ps=0u w=840000u l=150000u
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X27 a_1300_47# a_1178_261# a_1228_47# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X28 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X29 a_1178_261# a_1028_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X30 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X31 VPWR SET_B a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X33 VGND SET_B a_1300_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 VGND VPWR X A VNB VPB
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 VPWR VGND A X VNB VPB
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=3.139e+11p ps=3.35e+06u w=650000u l=150000u
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.949e+11p pd=4.03e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt NON_CLK_GEN clk clk_in clk0 clk0b clk1 clk1b control rst_n VPWR VGND
Xsky130_fd_sc_hd__nand2_1_9 VGND VPWR sky130_fd_sc_hd__nand3_1_2/B sky130_fd_sc_hd__inv_1_5/A
+ sky130_fd_sc_hd__inv_1_8/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_4 VGND VPWR sky130_fd_sc_hd__inv_1_4/Y sky130_fd_sc_hd__inv_1_4/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_5 VGND VPWR sky130_fd_sc_hd__inv_1_5/Y sky130_fd_sc_hd__inv_1_5/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_6 VGND VPWR sky130_fd_sc_hd__inv_1_6/Y sky130_fd_sc_hd__inv_1_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfstp_1_0 VPWR VGND sky130_fd_sc_hd__dfstp_1_5/Q sky130_fd_sc_hd__dfstp_1_1/D
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__inv_1_7 VGND VPWR sky130_fd_sc_hd__inv_1_7/Y sky130_fd_sc_hd__inv_1_7/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfstp_1_1 VPWR VGND sky130_fd_sc_hd__dfstp_1_1/D sky130_fd_sc_hd__inv_1_1/A
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__inv_1_8 VGND VPWR sky130_fd_sc_hd__inv_1_8/Y sky130_fd_sc_hd__inv_1_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dfstp_1_2 VPWR VGND sky130_fd_sc_hd__dfstp_1_9/Q sky130_fd_sc_hd__dfstp_1_5/D
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__inv_1_9 VGND VPWR sky130_fd_sc_hd__inv_1_9/Y sky130_fd_sc_hd__inv_1_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__nor2_1_0 VGND VPWR sky130_fd_sc_hd__inv_1_9/A sky130_fd_sc_hd__nor2_1_0/Y
+ sky130_fd_sc_hd__inv_1_7/A VGND VPWR sky130_fd_sc_hd__nor2_1
Xsky130_fd_sc_hd__dfstp_1_3 VPWR VGND sky130_fd_sc_hd__dfstp_1_8/Q sky130_fd_sc_hd__dfstp_1_6/D
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__clkbuf_4_0 VGND VPWR sky130_fd_sc_hd__clkbuf_4_0/X rst_n VGND VPWR
+ sky130_fd_sc_hd__clkbuf_4
Xsky130_fd_sc_hd__dfstp_1_4 VPWR VGND sky130_fd_sc_hd__inv_1_5/A sky130_fd_sc_hd__inv_1_3/A
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__clkbuf_4_1 VGND VPWR sky130_fd_sc_hd__clkbuf_4_1/X sky130_fd_sc_hd__clkbuf_4_3/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_4
Xsky130_fd_sc_hd__dfstp_1_5 VPWR VGND sky130_fd_sc_hd__dfstp_1_5/D sky130_fd_sc_hd__dfstp_1_5/Q
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__nand2_2_0 VGND VPWR sky130_fd_sc_hd__inv_1_0/A sky130_fd_sc_hd__nand2_2_0/A
+ sky130_fd_sc_hd__nand3_1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_2
Xsky130_fd_sc_hd__clkbuf_4_2 VGND VPWR sky130_fd_sc_hd__clkbuf_4_2/X sky130_fd_sc_hd__clkbuf_4_3/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_4
Xsky130_fd_sc_hd__nand2_1_10 VGND VPWR sky130_fd_sc_hd__nand3_1_1/B sky130_fd_sc_hd__inv_1_5/A
+ sky130_fd_sc_hd__inv_1_12/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__dfstp_1_6 VPWR VGND sky130_fd_sc_hd__dfstp_1_6/D sky130_fd_sc_hd__inv_1_5/A
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__nand2_2_1 VGND VPWR sky130_fd_sc_hd__inv_2_0/A sky130_fd_sc_hd__inv_1_7/A
+ sky130_fd_sc_hd__inv_1_9/A VGND VPWR sky130_fd_sc_hd__nand2_2
Xsky130_fd_sc_hd__clkbuf_4_3 VGND VPWR sky130_fd_sc_hd__clkbuf_4_3/X clk VGND VPWR
+ sky130_fd_sc_hd__clkbuf_4
Xsky130_fd_sc_hd__clkbuf_2_0 VGND VPWR clk_in sky130_fd_sc_hd__inv_1_9/A VGND VPWR
+ sky130_fd_sc_hd__clkbuf_2
Xsky130_fd_sc_hd__nand2_1_11 VGND VPWR sky130_fd_sc_hd__nand2_2_0/A sky130_fd_sc_hd__inv_1_2/Y
+ sky130_fd_sc_hd__nand2_1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__dfstp_1_7 VPWR VGND sky130_fd_sc_hd__nand2_1_3/Y sky130_fd_sc_hd__dfstp_1_8/D
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__nand2_1_12 VGND VPWR sky130_fd_sc_hd__nand3_1_2/A sky130_fd_sc_hd__inv_1_5/Y
+ sky130_fd_sc_hd__inv_1_11/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__dfstp_1_8 VPWR VGND sky130_fd_sc_hd__dfstp_1_8/D sky130_fd_sc_hd__dfstp_1_8/Q
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__dfstp_1_9 VPWR VGND sky130_fd_sc_hd__dfstp_1_9/D sky130_fd_sc_hd__dfstp_1_9/Q
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1
Xsky130_fd_sc_hd__buf_16_0 VGND VPWR sky130_fd_sc_hd__buf_16_0/A clk1b VGND VPWR sky130_fd_sc_hd__buf_16
Xsky130_fd_sc_hd__buf_2_0 VPWR VGND sky130_fd_sc_hd__buf_2_0/X sky130_fd_sc_hd__inv_1_0/A
+ VGND VPWR sky130_fd_sc_hd__buf_2
Xsky130_fd_sc_hd__inv_2_0 VPWR VGND sky130_fd_sc_hd__inv_2_0/A sky130_fd_sc_hd__inv_2_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_2
Xsky130_fd_sc_hd__buf_16_1 VGND VPWR sky130_fd_sc_hd__inv_2_0/Y clk0 VGND VPWR sky130_fd_sc_hd__buf_16
Xsky130_fd_sc_hd__buf_16_2 VGND VPWR sky130_fd_sc_hd__nor2_1_0/Y clk1 VGND VPWR sky130_fd_sc_hd__buf_16
Xsky130_fd_sc_hd__buf_16_3 VGND VPWR sky130_fd_sc_hd__inv_2_0/A clk0b VGND VPWR sky130_fd_sc_hd__buf_16
Xsky130_fd_sc_hd__nand3_1_0 VGND VPWR sky130_fd_sc_hd__nand3_1_0/Y sky130_fd_sc_hd__nand3_1_0/A
+ sky130_fd_sc_hd__inv_1_2/A sky130_fd_sc_hd__nand3_1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1
Xsky130_fd_sc_hd__nand3_1_1 VGND VPWR sky130_fd_sc_hd__nand3_1_1/Y sky130_fd_sc_hd__nand3_1_1/A
+ sky130_fd_sc_hd__inv_1_3/A sky130_fd_sc_hd__nand3_1_1/B VGND VPWR sky130_fd_sc_hd__nand3_1
Xsky130_fd_sc_hd__nand3_1_2 VGND VPWR sky130_fd_sc_hd__nand3_1_2/Y sky130_fd_sc_hd__nand3_1_2/A
+ sky130_fd_sc_hd__inv_1_10/Y sky130_fd_sc_hd__nand3_1_2/B VGND VPWR sky130_fd_sc_hd__nand3_1
Xsky130_fd_sc_hd__dfstp_2_0 VPWR VGND sky130_fd_sc_hd__inv_1_4/A sky130_fd_sc_hd__buf_2_0/X
+ sky130_fd_sc_hd__clkbuf_4_0/X sky130_fd_sc_hd__clkbuf_4_1/X VGND VPWR sky130_fd_sc_hd__dfstp_2
Xsky130_fd_sc_hd__nand2_1_0 VGND VPWR sky130_fd_sc_hd__nand2_1_0/Y sky130_fd_sc_hd__nand3_1_0/B
+ sky130_fd_sc_hd__nand3_1_0/A VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__nand2_1_1 VGND VPWR sky130_fd_sc_hd__nand2_1_3/A sky130_fd_sc_hd__inv_1_0/A
+ sky130_fd_sc_hd__inv_1_3/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__clkbuf_1_0 VGND VPWR sky130_fd_sc_hd__inv_1_2/A control VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1
Xsky130_fd_sc_hd__nand2_1_2 VGND VPWR sky130_fd_sc_hd__nand2_1_3/B sky130_fd_sc_hd__inv_1_3/A
+ sky130_fd_sc_hd__inv_1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__nand2_1_3 VGND VPWR sky130_fd_sc_hd__nand2_1_3/Y sky130_fd_sc_hd__nand2_1_3/B
+ sky130_fd_sc_hd__nand2_1_3/A VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__nand2_1_4 VGND VPWR sky130_fd_sc_hd__nand3_1_0/B sky130_fd_sc_hd__inv_1_4/A
+ sky130_fd_sc_hd__inv_1_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_10 VGND VPWR sky130_fd_sc_hd__inv_1_10/Y sky130_fd_sc_hd__inv_1_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__nand2_1_5 VGND VPWR sky130_fd_sc_hd__nand3_1_0/A sky130_fd_sc_hd__inv_1_1/A
+ sky130_fd_sc_hd__inv_1_4/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_0 VGND VPWR sky130_fd_sc_hd__inv_1_0/Y sky130_fd_sc_hd__inv_1_0/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_11 VGND VPWR sky130_fd_sc_hd__inv_1_11/Y sky130_fd_sc_hd__inv_1_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__nand2_1_6 VGND VPWR sky130_fd_sc_hd__buf_16_0/A sky130_fd_sc_hd__inv_1_6/Y
+ sky130_fd_sc_hd__inv_1_7/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_1 VGND VPWR sky130_fd_sc_hd__inv_1_1/Y sky130_fd_sc_hd__inv_1_1/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__inv_1_12 VGND VPWR sky130_fd_sc_hd__inv_1_12/Y sky130_fd_sc_hd__inv_1_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__dlygate4sd1_1_0 VPWR VGND sky130_fd_sc_hd__inv_1_4/A sky130_fd_sc_hd__dfstp_1_9/D
+ VGND VPWR sky130_fd_sc_hd__dlygate4sd1_1
Xsky130_fd_sc_hd__nand2_1_7 VGND VPWR sky130_fd_sc_hd__nand3_1_1/A sky130_fd_sc_hd__inv_1_9/Y
+ sky130_fd_sc_hd__inv_1_5/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_2 VGND VPWR sky130_fd_sc_hd__inv_1_2/Y sky130_fd_sc_hd__inv_1_2/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
Xsky130_fd_sc_hd__nand2_1_8 VGND VPWR sky130_fd_sc_hd__inv_1_7/A sky130_fd_sc_hd__nand3_1_1/Y
+ sky130_fd_sc_hd__nand3_1_2/Y VGND VPWR sky130_fd_sc_hd__nand2_1
Xsky130_fd_sc_hd__inv_1_3 VGND VPWR sky130_fd_sc_hd__inv_1_3/Y sky130_fd_sc_hd__inv_1_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1
.ends

.subckt DCDC_CLKGATE VNB VPB CLK GCLK GATE
X0 VPB a_n10903_655# a_n10954_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.0444e+12p pd=1.028e+07u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X1 a_n10779_472# a_n10903_655# a_n11165_605# VNB sky130_fd_pr__nfet_01v8 ad=2.3425e+11p pd=2.17e+06u as=2.384e+11p ps=2.18e+06u w=420000u l=150000u
X2 a_n11345_427# a_n11165_605# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X3 a_n10945_819# a_n11345_427# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X4 a_n11019_453# a_n11345_427# VNB VNB sky130_fd_pr__nfet_01v8 ad=1.3425e+11p pd=1.49e+06u as=6.7175e+11p ps=6.86e+06u w=420000u l=150000u
X5 VNB a_n11513_605# GCLK VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X6 VNB a_n11165_605# a_n11345_427# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_n11513_605# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=4.064e+11p pd=2.55e+06u as=0p ps=0u w=640000u l=150000u
X8 a_n11387_453# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X9 a_n10903_655# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X10 VNB a_n10903_655# a_n10954_427# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X11 a_n10749_819# a_n10954_427# a_n11165_605# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.915e+11p pd=1.93e+06u as=1.974e+11p ps=1.78e+06u w=420000u l=150000u
X12 VPB a_n11345_427# a_n11513_605# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 a_n11165_605# a_n10903_655# a_n10945_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_n11513_605# a_n11345_427# a_n11387_453# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X15 a_n11165_605# a_n10954_427# a_n11019_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=390000u l=150000u
X16 VNB GATE a_n10779_472# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 VPB a_n11513_605# GCLK VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X18 VPB GATE a_n10749_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X19 a_n10903_655# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NOISE_INJECTION D[3] D[0] D[1] D[2] bias_out Noise_in VSS
X0 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=2.6712e+12p pd=3.288e+07u as=3.528e+11p ps=4.2e+06u w=420000u l=150000u
X1 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 bias_out a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X4 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X5 Noise_in a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X6 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 bias_out a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X8 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X9 Noise_in a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X10 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X16 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 bias_out a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X19 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 Noise_in a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X23 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 bias_out a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X29 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 Noise_in a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
.ends

.subckt sky130_fd_sc_hd__inv_1$1 VGND VPWR Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_1$1 VGND VPWR Y B A VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__ha_1 VGND VPWR B A COUT SUM VNB VPB
X0 a_297_47# a_250_199# a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X1 a_297_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=4.764e+11p ps=5.15e+06u w=420000u l=150000u
X2 COUT a_250_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=1.0518e+12p ps=8.44e+06u w=1e+06u l=150000u
X3 a_250_199# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.218e+11p pd=1.42e+06u as=0p ps=0u w=420000u l=150000u
X4 a_376_413# B a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.68e+11p pd=1.64e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X5 a_79_21# a_250_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_674_47# B a_250_199# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 VPWR A a_376_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 COUT a_250_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_79_21# SUM VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X11 VPWR A a_250_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VGND A a_674_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VGND a_79_21# SUM VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand4_1 VPWR VGND C B Y D A VNB VPB
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=6e+11p pd=5.2e+06u as=8.3e+11p ps=7.66e+06u w=1e+06u l=150000u
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=1.95e+11p pd=1.9e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkinv_2 VPWR VGND Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.205e+11p ps=2.73e+06u w=420000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.45e+11p pd=5.09e+06u as=5.45e+11p ps=5.09e+06u w=1e+06u l=150000u
X2 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_1 VGND VPWR A2 B1 Y A1 B2 VNB VPB
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.6875e+11p ps=5.65e+06u w=650000u l=150000u
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.8525e+11p ps=1.87e+06u w=650000u l=150000u
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=4.65e+11p ps=2.93e+06u w=1e+06u l=150000u
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.25e+11p ps=2.45e+06u w=1e+06u l=150000u
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1$1 VGND VPWR X A VNB VPB
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2$1 VGND VPWR A X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_1 VGND VPWR A2 A1 B1 Y VNB VPB
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.48e+11p pd=2.78e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=4.42e+11p pd=4.44e+06u as=0p ps=0u w=700000u l=150000u
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_2$1 VGND VPWR Y A B VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=7.9e+11p pd=7.58e+06u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2$1 VPWR VGND A Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_1 VPWR VGND A1 B1 Y A2 VNB VPB
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=1.9175e+11p pd=1.89e+06u as=1.82e+11p ps=1.86e+06u w=650000u l=150000u
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.45e+11p pd=5.09e+06u as=2.95e+11p ps=2.59e+06u w=1e+06u l=150000u
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 VPWR VGND A X VNB VPB
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=8.445e+11p ps=7.95e+06u w=1e+06u l=150000u
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=5.82e+11p pd=5.85e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_1$1 VGND VPWR Y A C B VNB VPB
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.9e+11p pd=5.18e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_1$1 VGND VPWR B Y A VNB VPB
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor3_1 VGND VPWR C Y A B VNB VPB
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_0 VGND VPWR Y B1 A2 A1 VNB VPB
X0 a_120_369# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.536e+11p pd=1.76e+06u as=3.52e+11p ps=3.66e+06u w=640000u l=150000u
X1 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.289e+11p ps=2.77e+06u w=420000u l=150000u
X2 Y A2 a_120_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.792e+11p pd=1.84e+06u as=0p ps=0u w=640000u l=150000u
X3 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__xor2_1 VPWR VGND B X A VNB VPB
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=3e+11p pd=2.6e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=5.005e+11p pd=2.84e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.525e+11p ps=5.6e+06u w=650000u l=150000u
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21bai_1 VPWR VGND A1 Y B1_N A2 VNB VPB
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.55e+11p pd=2.51e+06u as=3.05e+11p ps=2.61e+06u w=1e+06u l=150000u
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=2.847e+11p ps=3.2e+06u w=420000u l=150000u
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=6.365e+11p pd=5.36e+06u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt dcdc_config VPWR a[0] a[1] a[2] a[3] a[4] a[5] s[0] s[10] s[11] s[1] s[2]
+ s[3] s[4] s[5] s[6] s[7] s[8] s[9] VGND
Xsky130_fd_sc_hd__inv_1$1_4 VGND VPWR sky130_fd_sc_hd__inv_1$1_4/Y sky130_fd_sc_hd__inv_1$1_4/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_10 VGND VPWR sky130_fd_sc_hd__nand2_1$1_10/Y sky130_fd_sc_hd__a21oi_1_0/A2
+ sky130_fd_sc_hd__a21oi_1_0/A1 VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__inv_1$1_5 VGND VPWR sky130_fd_sc_hd__nor3_1_1/A sky130_fd_sc_hd__nor3_1_0/B
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_11 VGND VPWR sky130_fd_sc_hd__nand2_1$1_12/A sky130_fd_sc_hd__inv_1$1_8/Y
+ sky130_fd_sc_hd__nand3_1$1_5/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__inv_1$1_6 VGND VPWR sky130_fd_sc_hd__inv_1$1_6/Y sky130_fd_sc_hd__ha_1_0/SUM
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_12 VGND VPWR sky130_fd_sc_hd__nand2_1$1_12/Y sky130_fd_sc_hd__nand4_1_0/Y
+ sky130_fd_sc_hd__nand2_1$1_12/A VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__ha_1_0 VGND VPWR sky130_fd_sc_hd__ha_1_0/B sky130_fd_sc_hd__ha_1_0/A
+ sky130_fd_sc_hd__inv_1$1_8/A sky130_fd_sc_hd__ha_1_0/SUM VGND VPWR sky130_fd_sc_hd__ha_1
Xsky130_fd_sc_hd__inv_1$1_7 VGND VPWR sky130_fd_sc_hd__inv_1$1_7/Y sky130_fd_sc_hd__inv_1$1_7/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_13 VGND VPWR sky130_fd_sc_hd__nand2_1$1_13/Y sky130_fd_sc_hd__inv_1$1_7/A
+ sky130_fd_sc_hd__nand4_1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__inv_1$1_8 VGND VPWR sky130_fd_sc_hd__inv_1$1_8/Y sky130_fd_sc_hd__inv_1$1_8/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_14 VGND VPWR sky130_fd_sc_hd__clkinv_2_0/A sky130_fd_sc_hd__xor2_1_0/A
+ sky130_fd_sc_hd__inv_1$1_1/A VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__inv_1$1_9 VGND VPWR sky130_fd_sc_hd__inv_1$1_9/Y sky130_fd_sc_hd__o21ai_1_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand4_1_0 VPWR VGND sky130_fd_sc_hd__ha_1_0/A sky130_fd_sc_hd__nand4_1_0/B
+ sky130_fd_sc_hd__nand4_1_0/Y sky130_fd_sc_hd__ha_1_0/B sky130_fd_sc_hd__nand4_1_0/A
+ VGND VPWR sky130_fd_sc_hd__nand4_1
Xsky130_fd_sc_hd__nand2_1$1_15 VGND VPWR sky130_fd_sc_hd__nand2_1$1_16/B sky130_fd_sc_hd__inv_1$1_10/Y
+ sky130_fd_sc_hd__clkinv_2_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__nand2_1$1_16 VGND VPWR sky130_fd_sc_hd__ha_1_0/A sky130_fd_sc_hd__nand2_1$1_16/B
+ sky130_fd_sc_hd__nand3_1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__nand2_1$1_17 VGND VPWR sky130_fd_sc_hd__nand3_1$1_3/B sky130_fd_sc_hd__o21ai_0_1/A2
+ sky130_fd_sc_hd__nand3_1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__nand2_1$1_18 VGND VPWR sky130_fd_sc_hd__nand4_1_0/A sky130_fd_sc_hd__o21ai_0_1/A2
+ sky130_fd_sc_hd__nand2_1$1_19/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkinv_2_0 VPWR VGND sky130_fd_sc_hd__o21ai_0_2/B1 sky130_fd_sc_hd__clkinv_2_0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_2
Xsky130_fd_sc_hd__nand2_1$1_19 VGND VPWR sky130_fd_sc_hd__nand2_1$1_19/Y sky130_fd_sc_hd__o22ai_1_0/A2
+ sky130_fd_sc_hd__nand2_1$1_20/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkinv_2_1 VPWR VGND sky130_fd_sc_hd__clkinv_2_1/Y sky130_fd_sc_hd__o22ai_1_0/B2
+ VGND VPWR sky130_fd_sc_hd__clkinv_2
Xsky130_fd_sc_hd__o22ai_1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1_0/A2 sky130_fd_sc_hd__inv_1$1_3/A
+ sky130_fd_sc_hd__o22ai_1_0/Y sky130_fd_sc_hd__xor2_1_0/B sky130_fd_sc_hd__o22ai_1_0/B2
+ VGND VPWR sky130_fd_sc_hd__o22ai_1
Xsky130_fd_sc_hd__clkbuf_1$1_10 VGND VPWR s[3] sky130_fd_sc_hd__nand2_1$1_12/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__clkbuf_2$1_0 VGND VPWR a[3] sky130_fd_sc_hd__xor2_1_0/B VGND VPWR
+ sky130_fd_sc_hd__clkbuf_2$1
Xsky130_fd_sc_hd__clkbuf_1$1_11 VGND VPWR s[4] sky130_fd_sc_hd__nor3_1_1/C VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__clkbuf_2$1_1 VGND VPWR a[4] sky130_fd_sc_hd__o21ai_0_1/A2 VGND VPWR
+ sky130_fd_sc_hd__clkbuf_2$1
Xsky130_fd_sc_hd__o21ai_1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1_0/B2 sky130_fd_sc_hd__nor3_1_1/A
+ sky130_fd_sc_hd__o22ai_1_0/A2 sky130_fd_sc_hd__o21ai_1_0/Y VGND VPWR sky130_fd_sc_hd__o21ai_1
Xsky130_fd_sc_hd__clkbuf_1$1_12 VGND VPWR s[0] sky130_fd_sc_hd__nand2_1$1_13/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__clkbuf_2$1_2 VGND VPWR a[5] sky130_fd_sc_hd__nor3_1_0/B VGND VPWR
+ sky130_fd_sc_hd__clkbuf_2$1
Xsky130_fd_sc_hd__clkbuf_1$1_13 VGND VPWR s[5] sky130_fd_sc_hd__inv_1$1_6/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand2_2$1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1_0/B2 sky130_fd_sc_hd__o21ai_0_2/Y
+ sky130_fd_sc_hd__nor3_1_0/C VGND VPWR sky130_fd_sc_hd__nand2_2$1
Xsky130_fd_sc_hd__inv_1$1_10 VGND VPWR sky130_fd_sc_hd__inv_1$1_10/Y sky130_fd_sc_hd__o21ai_0_1/A2
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__inv_2$1_0 VPWR VGND sky130_fd_sc_hd__ha_1_0/A sky130_fd_sc_hd__nor3_1_1/C
+ VGND VPWR sky130_fd_sc_hd__inv_2$1
Xsky130_fd_sc_hd__a21oi_1_0 VPWR VGND sky130_fd_sc_hd__a21oi_1_0/A1 sky130_fd_sc_hd__o21ai_1_0/Y
+ sky130_fd_sc_hd__ha_1_0/B sky130_fd_sc_hd__a21oi_1_0/A2 VGND VPWR sky130_fd_sc_hd__a21oi_1
Xsky130_fd_sc_hd__clkbuf_1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1_1/A a[1] VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__a21oi_1_1 VPWR VGND sky130_fd_sc_hd__a21oi_1_1/A1 sky130_fd_sc_hd__nor3_1_1/Y
+ sky130_fd_sc_hd__inv_1$1_7/A sky130_fd_sc_hd__inv_1$1_2/Y VGND VPWR sky130_fd_sc_hd__a21oi_1
Xsky130_fd_sc_hd__clkbuf_1$1_1 VGND VPWR sky130_fd_sc_hd__xor2_1_0/A a[0] VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__dlymetal6s2s_1_0 VPWR VGND a[2] sky130_fd_sc_hd__inv_1$1_3/A VGND
+ VPWR sky130_fd_sc_hd__dlymetal6s2s_1
Xsky130_fd_sc_hd__clkbuf_1$1_2 VGND VPWR s[6] sky130_fd_sc_hd__o21ai_1_0/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_0 VGND VPWR sky130_fd_sc_hd__nand3_1$1_0/Y sky130_fd_sc_hd__o22ai_1_0/B2
+ sky130_fd_sc_hd__nand3_1$1_1/Y sky130_fd_sc_hd__nand3_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_3 VGND VPWR s[7] sky130_fd_sc_hd__o21bai_1_0/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_1 VGND VPWR sky130_fd_sc_hd__nand3_1$1_1/Y sky130_fd_sc_hd__o21ai_0_0/Y
+ sky130_fd_sc_hd__nand3_1$1_1/C sky130_fd_sc_hd__nor3_1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__nand2_1$1_0 VGND VPWR sky130_fd_sc_hd__nor3_1_0/C sky130_fd_sc_hd__inv_1$1_0/Y
+ sky130_fd_sc_hd__inv_1$1_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__nor2_1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1_3/A sky130_fd_sc_hd__nor3_1_1/B
+ sky130_fd_sc_hd__o21ai_0_1/A2 VGND VPWR sky130_fd_sc_hd__nor2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_4 VGND VPWR s[8] sky130_fd_sc_hd__clkinv_2_1/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_2 VGND VPWR sky130_fd_sc_hd__nand4_1_0/B sky130_fd_sc_hd__o21ai_0_1/Y
+ sky130_fd_sc_hd__o22ai_1_0/A2 sky130_fd_sc_hd__xor2_1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__nand2_1$1_1 VGND VPWR sky130_fd_sc_hd__o22ai_1_0/A2 sky130_fd_sc_hd__nand3_1$1_1/C
+ sky130_fd_sc_hd__o21ai_0_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_5 VGND VPWR s[9] sky130_fd_sc_hd__nand2_1$1_10/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_3 VGND VPWR sky130_fd_sc_hd__a21oi_1_1/A1 sky130_fd_sc_hd__inv_1$1_9/Y
+ sky130_fd_sc_hd__o22ai_1_0/B2 sky130_fd_sc_hd__nand3_1$1_3/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__nand2_1$1_2 VGND VPWR sky130_fd_sc_hd__nand3_1$1_0/B sky130_fd_sc_hd__xor2_1_0/X
+ sky130_fd_sc_hd__o22ai_1_0/A2 VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_6 VGND VPWR s[11] sky130_fd_sc_hd__inv_1$1_4/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_4 VGND VPWR sky130_fd_sc_hd__nand3_1$1_5/C sky130_fd_sc_hd__nor3_1_1/C
+ sky130_fd_sc_hd__inv_1$1_9/Y sky130_fd_sc_hd__nor3_1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__nand2_1$1_3 VGND VPWR sky130_fd_sc_hd__nand2_1$1_8/B sky130_fd_sc_hd__nor3_1_1/B
+ sky130_fd_sc_hd__nor3_1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_7 VGND VPWR s[10] sky130_fd_sc_hd__inv_1$1_4/A VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nand3_1$1_5 VGND VPWR sky130_fd_sc_hd__nand3_1$1_5/Y sky130_fd_sc_hd__nand4_1_0/A
+ sky130_fd_sc_hd__nand3_1$1_5/C sky130_fd_sc_hd__nand4_1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1
Xsky130_fd_sc_hd__nand2_1$1_4 VGND VPWR sky130_fd_sc_hd__o21ai_0_2/A1 sky130_fd_sc_hd__nor3_1_0/B
+ sky130_fd_sc_hd__o21ai_0_1/A2 VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_8 VGND VPWR s[1] sky130_fd_sc_hd__inv_1$1_7/Y VGND VPWR
+ sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nor3_1_0 VGND VPWR sky130_fd_sc_hd__nor3_1_0/C sky130_fd_sc_hd__nor3_1_0/Y
+ sky130_fd_sc_hd__xor2_1_0/B sky130_fd_sc_hd__nor3_1_0/B VGND VPWR sky130_fd_sc_hd__nor3_1
Xsky130_fd_sc_hd__nand2_1$1_5 VGND VPWR sky130_fd_sc_hd__nand3_1$1_1/C sky130_fd_sc_hd__inv_1$1_3/Y
+ sky130_fd_sc_hd__clkinv_2_0/A VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__clkbuf_1$1_9 VGND VPWR s[2] sky130_fd_sc_hd__nand3_1$1_5/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1
Xsky130_fd_sc_hd__nor3_1_1 VGND VPWR sky130_fd_sc_hd__nor3_1_1/C sky130_fd_sc_hd__nor3_1_1/Y
+ sky130_fd_sc_hd__nor3_1_1/A sky130_fd_sc_hd__nor3_1_1/B VGND VPWR sky130_fd_sc_hd__nor3_1
Xsky130_fd_sc_hd__nand2_1$1_6 VGND VPWR sky130_fd_sc_hd__o21ai_0_2/A2 sky130_fd_sc_hd__inv_1$1_3/A
+ sky130_fd_sc_hd__xor2_1_0/B VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__o21ai_0_0 VGND VPWR sky130_fd_sc_hd__o21ai_0_0/Y sky130_fd_sc_hd__inv_1$1_3/A
+ sky130_fd_sc_hd__xor2_1_0/A sky130_fd_sc_hd__inv_1$1_1/A VGND VPWR sky130_fd_sc_hd__o21ai_0
Xsky130_fd_sc_hd__inv_1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1_0/Y sky130_fd_sc_hd__xor2_1_0/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_7 VGND VPWR sky130_fd_sc_hd__a21oi_1_0/A2 sky130_fd_sc_hd__o22ai_1_0/B2
+ sky130_fd_sc_hd__nand2_1$1_8/B VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__o21ai_0_1 VGND VPWR sky130_fd_sc_hd__o21ai_0_1/Y sky130_fd_sc_hd__o22ai_1_0/B2
+ sky130_fd_sc_hd__o21ai_0_1/A2 sky130_fd_sc_hd__inv_1$1_0/Y VGND VPWR sky130_fd_sc_hd__o21ai_0
Xsky130_fd_sc_hd__inv_1$1_1 VGND VPWR sky130_fd_sc_hd__inv_1$1_1/Y sky130_fd_sc_hd__inv_1$1_1/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_8 VGND VPWR sky130_fd_sc_hd__inv_1$1_4/A sky130_fd_sc_hd__nand2_1$1_8/B
+ sky130_fd_sc_hd__a21oi_1_0/A1 VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__xor2_1_0 VPWR VGND sky130_fd_sc_hd__xor2_1_0/B sky130_fd_sc_hd__xor2_1_0/X
+ sky130_fd_sc_hd__xor2_1_0/A VGND VPWR sky130_fd_sc_hd__xor2_1
Xsky130_fd_sc_hd__o21ai_0_2 VGND VPWR sky130_fd_sc_hd__o21ai_0_2/Y sky130_fd_sc_hd__o21ai_0_2/B1
+ sky130_fd_sc_hd__o21ai_0_2/A2 sky130_fd_sc_hd__o21ai_0_2/A1 VGND VPWR sky130_fd_sc_hd__o21ai_0
Xsky130_fd_sc_hd__inv_1$1_2 VGND VPWR sky130_fd_sc_hd__inv_1$1_2/Y sky130_fd_sc_hd__o22ai_1_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__o21bai_1_0 VPWR VGND sky130_fd_sc_hd__nor3_1_1/A sky130_fd_sc_hd__o21bai_1_0/Y
+ sky130_fd_sc_hd__ha_1_0/B sky130_fd_sc_hd__o22ai_1_0/B2 VGND VPWR sky130_fd_sc_hd__o21bai_1
Xsky130_fd_sc_hd__nand2_1$1_9 VGND VPWR sky130_fd_sc_hd__a21oi_1_0/A1 sky130_fd_sc_hd__o21ai_0_2/B1
+ sky130_fd_sc_hd__clkinv_2_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1
Xsky130_fd_sc_hd__inv_1$1_3 VGND VPWR sky130_fd_sc_hd__inv_1$1_3/Y sky130_fd_sc_hd__inv_1$1_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1
Xsky130_fd_sc_hd__nand2_1$1_20 VGND VPWR sky130_fd_sc_hd__nand2_1$1_20/Y sky130_fd_sc_hd__inv_1$1_1/Y
+ sky130_fd_sc_hd__ha_1_0/A VGND VPWR sky130_fd_sc_hd__nand2_1$1
.ends

.subckt DCDC_INVERTER VNB VPB A Y
X0 VPB A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X1 VNB A Y VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_RRZ644 c1_n842_n760# m3_n870_n788#
X0 c1_n842_n760# m3_n870_n788# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=8e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_F8PC2Z m3_n550_n300# c1_n450_n220#
X0 c1_n450_n220# m3_n550_n300# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_K8PL49$1 c1_n442_n400# m3_n470_n428#
X0 c1_n442_n400# m3_n470_n428# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_FJFAMD c1_n250_n200# m3_n291_n340#
X0 c1_n250_n200# m3_n291_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt PMOS_4T_48942251_X2_Y1_1653520168_1653520173 a_147_525# a_200_252# w_0_0#
+ a_230_525#
X0 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520167_1653520173 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt INV_B_13409687_0_1653520173 PMOS_4T_48942251_X2_Y1_1653520168_1653520173_0/w_0_0#
+ PMOS_4T_48942251_X2_Y1_1653520168_1653520173_0/a_147_525# m1_430_56# m1_430_896#
+ VSUBS
XPMOS_4T_48942251_X2_Y1_1653520168_1653520173_0 PMOS_4T_48942251_X2_Y1_1653520168_1653520173_0/a_147_525#
+ m1_430_896# PMOS_4T_48942251_X2_Y1_1653520168_1653520173_0/w_0_0# m1_430_56# PMOS_4T_48942251_X2_Y1_1653520168_1653520173
XNMOS_S_22639876_X1_Y1_1653520167_1653520173_0 VSUBS m1_430_896# m1_430_56# NMOS_S_22639876_X1_Y1_1653520167_1653520173
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4VD94C$1 c1_n1650_n792# m3_n1750_n820#
X0 c1_n1650_n792# m3_n1750_n820# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=1.6e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4CW8F2 c1_n842_n376# m3_n870_n410#
X0 c1_n842_n376# m3_n870_n410# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=8e+06u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520174 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_DAC RST VOUT D1 D4 D3 D5 D2 D0 VPWR m4_656_641# VGND
XC8_8 VOUT m1_3830_5595# sky130_fd_pr__cap_mim_m3_1_RRZ644
XC4_2 m1_3824_2469# VOUT sky130_fd_pr__cap_mim_m3_1_F8PC2Z
XC4_4 VOUT m1_2436_3089# sky130_fd_pr__cap_mim_m3_1_K8PL49$1
XC2_2 VOUT VGND sky130_fd_pr__cap_mim_m3_1_FJFAMD
XINV_B_13409687_0_1653520173_0 VPWR VPWR m1_2452_2549# D0 VGND INV_B_13409687_0_1653520173
XINV_B_13409687_0_1653520173_1 VPWR VPWR m1_3830_3805# D3 VGND INV_B_13409687_0_1653520173
XINV_B_13409687_0_1653520173_3 VPWR VPWR m1_2470_5595# D5 VGND INV_B_13409687_0_1653520173
XINV_B_13409687_0_1653520173_2 VPWR VPWR m1_3830_5595# D4 VGND INV_B_13409687_0_1653520173
XINV_B_13409687_0_1653520173_4 VPWR VPWR m1_2436_3089# D2 VGND INV_B_13409687_0_1653520173
XINV_B_13409687_0_1653520173_5 VPWR VPWR m1_3824_2469# D1 VGND INV_B_13409687_0_1653520173
Xsky130_fd_pr__cap_mim_m3_1_4VD94C$1_0 VOUT m1_2470_5595# sky130_fd_pr__cap_mim_m3_1_4VD94C$1
Xsky130_fd_pr__cap_mim_m3_1_4CW8F2_0 VOUT m1_3830_3805# sky130_fd_pr__cap_mim_m3_1_4CW8F2
Xsky130_fd_pr__cap_mim_m3_1_FJFAMD_0 VOUT m1_2452_2549# sky130_fd_pr__cap_mim_m3_1_FJFAMD
XNMOS_S_22639876_X1_Y1_1653520174_0 VGND RST VOUT NMOS_S_22639876_X1_Y1_1653520174
.ends

.subckt DCDC_FF VNB VPB D CLK Q
X0 VPB a_n15141_427# a_n15212_453# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.02105e+12p pd=9.61e+06u as=2.19e+11p ps=2.15e+06u w=750000u l=150000u
X1 a_n15632_427# a_n15348_427# a_n15413_453# VNB sky130_fd_pr__nfet_01v8 ad=1.368e+11p pd=1.48e+06u as=1.32e+11p ps=1.49e+06u w=360000u l=150000u
X2 a_n15141_427# a_n15341_727# a_n14992_453# VNB sky130_fd_pr__nfet_01v8 ad=1.242e+11p pd=1.41e+06u as=1.392e+11p ps=1.53e+06u w=360000u l=150000u
X3 VPB a_n15348_427# a_n15341_727# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 VNB a_n15728_605# Q VNB sky130_fd_pr__nfet_01v8 ad=7.492e+11p pd=8.11e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X5 a_n15348_427# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X6 a_n15212_453# a_n15341_727# a_n15632_427# VNB sky130_fd_pr__nfet_01v8 ad=1.978e+11p pd=1.99e+06u as=0p ps=0u w=360000u l=150000u
X7 a_n15141_427# a_n15348_427# a_n14965_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.365e+11p pd=1.49e+06u as=1.533e+11p ps=1.57e+06u w=420000u l=150000u
X8 a_n15728_605# a_n15632_427# VNB VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X9 VPB a_n15728_605# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X10 VNB a_n15141_427# a_n15212_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X11 a_n14992_453# a_n15212_453# VNB VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_n15728_605# a_n15632_427# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X13 VNB a_n15348_427# a_n15341_727# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X14 a_n14794_453# a_n15341_727# a_n15141_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.155e+11p pd=1.39e+06u as=0p ps=0u w=420000u l=150000u
X15 a_n14965_819# a_n15212_453# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_n14794_453# a_n15348_427# a_n15141_427# VNB sky130_fd_pr__nfet_01v8 ad=1.626e+11p pd=1.66e+06u as=0p ps=0u w=360000u l=150000u
X17 a_n15632_427# a_n15341_727# a_n15390_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.764e+11p ps=1.68e+06u w=420000u l=150000u
X18 a_n15348_427# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 a_n15212_453# a_n15348_427# a_n15632_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VPB D a_n14794_453# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_n15390_819# a_n15728_605# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 VNB D a_n14794_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_n15413_453# a_n15728_605# VNB VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_CAP_UNIT m3_72_0# c1_100_100#
X0 c1_100_100# m3_72_0# sky130_fd_pr__cap_mim_m3_1 l=1.9e+07u w=7e+06u
.ends

.subckt DCAP_PMOS_98843368_X1_Y_f9c0cc87 a_n13_252# w_n118_0#
X0 w_n118_0# a_n13_252# w_n118_0# w_n118_0# sky130_fd_pr__pfet_01v8 ad=1.365e+12p pd=9.7e+06u as=0p ps=0u w=2.1e+06u l=2.1e+06u
.ends

.subckt DP_PMOS_B_25364157_X1_Y_12b887c0 a_230_441# a_405_441# a_372_897# a_200_252#
+ a_147_441# w_0_0#
X0 a_147_441# a_372_897# a_405_441# w_0_0# sky130_fd_pr__pfet_01v8 ad=6.678e+11p pd=6.1e+06u as=3.339e+11p ps=3.05e+06u w=1.26e+06u l=150000u
X1 a_230_441# a_200_252# a_147_441# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.339e+11p pd=3.05e+06u as=0p ps=0u w=1.26e+06u l=150000u
.ends

.subckt CCP_PMOS_B_88242555_X1__44b71c81 a_147_525# a_200_252# w_0_0# a_230_525#
X0 a_147_525# a_230_525# a_200_252# w_0_0# sky130_fd_pr__pfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_XSW_PMOS_0_1650326_40a43b21 DP_PMOS_B_25364157_X1_Y_12b887c0_0/a_230_441#
+ m1_1290_1316# DP_PMOS_B_25364157_X1_Y_12b887c0_0/a_405_441# DCAP_PMOS_98843368_X1_Y_f9c0cc87_0/w_n118_0#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87_1/w_n118_0# m1_1376_224#
XDCAP_PMOS_98843368_X1_Y_f9c0cc87_0 li_405_907# DCAP_PMOS_98843368_X1_Y_f9c0cc87_0/w_n118_0#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87
XDCAP_PMOS_98843368_X1_Y_f9c0cc87_1 li_1437_823# DCAP_PMOS_98843368_X1_Y_f9c0cc87_1/w_n118_0#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87
XDP_PMOS_B_25364157_X1_Y_12b887c0_0 DP_PMOS_B_25364157_X1_Y_12b887c0_0/a_230_441#
+ DP_PMOS_B_25364157_X1_Y_12b887c0_0/a_405_441# li_405_907# li_1437_823# m1_1376_224#
+ m1_1290_1316# DP_PMOS_B_25364157_X1_Y_12b887c0
XCCP_PMOS_B_88242555_X1__44b71c81_0 m1_1376_224# li_405_907# m1_1290_1316# li_1437_823#
+ CCP_PMOS_B_88242555_X1__44b71c81
.ends

.subckt CCP_NMOS_B_82699349_X1__3a37f603 a_147_525# a_200_252# a_241_1232# a_230_525#
X0 a_147_525# a_230_525# a_200_252# a_241_1232# sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DP_NMOS_B_83449181_X1_Y_edeae765 a_372_897# a_200_252# a_230_483# a_405_483#
+ a_241_1232# a_147_483#
X0 a_147_483# a_372_897# a_405_483# a_241_1232# sky130_fd_pr__nfet_01v8 ad=4.452e+11p pd=4.42e+06u as=2.226e+11p ps=2.21e+06u w=840000u l=150000u
X1 a_230_483# a_200_252# a_147_483# a_241_1232# sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.21e+06u as=0p ps=0u w=840000u l=150000u
.ends

.subckt DCAP_PMOS_98843368_X1_Y_1407ea6c a_n206_897# w_n360_0#
X0 w_n360_0# a_n206_897# w_n360_0# w_n360_0# sky130_fd_pr__pfet_01v8 ad=2.625e+12p pd=1.09e+07u as=0p ps=0u w=2.1e+06u l=2.1e+06u
.ends

.subckt DCDC_XSW_NMOS_0_1650326_24c8b01c DP_NMOS_B_83449181_X1_Y_edeae765_0/a_230_483#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c_1/w_n360_0# VSUBS DP_NMOS_B_83449181_X1_Y_edeae765_0/a_405_483#
+ m1_1376_224# DCAP_PMOS_98843368_X1_Y_1407ea6c_0/w_n360_0#
XCCP_NMOS_B_82699349_X1__3a37f603_0 m1_1376_224# li_405_907# VSUBS li_1437_823# CCP_NMOS_B_82699349_X1__3a37f603
XDP_NMOS_B_83449181_X1_Y_edeae765_0 li_405_907# li_1437_823# DP_NMOS_B_83449181_X1_Y_edeae765_0/a_230_483#
+ DP_NMOS_B_83449181_X1_Y_edeae765_0/a_405_483# VSUBS m1_1376_224# DP_NMOS_B_83449181_X1_Y_edeae765
XDCAP_PMOS_98843368_X1_Y_1407ea6c_0 li_405_907# DCAP_PMOS_98843368_X1_Y_1407ea6c_0/w_n360_0#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c
XDCAP_PMOS_98843368_X1_Y_1407ea6c_1 li_1437_823# DCAP_PMOS_98843368_X1_Y_1407ea6c_1/w_n360_0#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c
.ends

.subckt DCDC_HUNIT_CONV2TO1_0_1_73a3675f m1_1086_1316# m1_1258_1400# DCDC_XSW_NMOS_0_1650326_24c8b01c_0/DCAP_PMOS_98843368_X1_Y_1407ea6c_0/w_n360_0#
+ DCDC_XSW_NMOS_0_1650326_24c8b01c_0/DCAP_PMOS_98843368_X1_Y_1407ea6c_1/w_n360_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1290_1316# VSUBS DCDC_XSW_PMOS_0_1650326_40a43b21_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87_0/w_n118_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224# DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224#
+ DCDC_XSW_PMOS_0_1650326_40a43b21_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87_1/w_n118_0#
XDCDC_XSW_PMOS_0_1650326_40a43b21_0 m1_1258_1400# DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1290_1316#
+ m1_1086_1316# DCDC_XSW_PMOS_0_1650326_40a43b21_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87_0/w_n118_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87_1/w_n118_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224# DCDC_XSW_PMOS_0_1650326_40a43b21
XDCDC_XSW_NMOS_0_1650326_24c8b01c_0 m1_1258_1400# DCDC_XSW_NMOS_0_1650326_24c8b01c_0/DCAP_PMOS_98843368_X1_Y_1407ea6c_1/w_n360_0#
+ VSUBS m1_1086_1316# DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224# DCDC_XSW_NMOS_0_1650326_24c8b01c_0/DCAP_PMOS_98843368_X1_Y_1407ea6c_0/w_n360_0#
+ DCDC_XSW_NMOS_0_1650326_24c8b01c
.ends

.subckt DCDC_CONV2TO1_0_1650326046 m1_1172_2072# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1086_1316#
+ m1_3150_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1258_1400# m1_140_1652# m1_3236_3332#
+ m1_54_3332# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224#
+ li_1695_151# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1086_1316# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224#
+ VSUBS DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1258_1400#
XDCDC_HUNIT_CONV2TO1_0_1_73a3675f_0 DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1086_1316#
+ DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1258_1400# m1_54_3332# m1_3236_3332# li_1695_151#
+ VSUBS m1_140_1652# m1_1172_2072# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224#
+ m1_3150_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f
XDCDC_HUNIT_CONV2TO1_0_1_73a3675f_1 DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1086_1316#
+ DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1258_1400# m1_54_3332# m1_3236_3332# li_1695_151#
+ VSUBS m1_140_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224#
+ m1_1172_2072# m1_3150_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f
.ends

.subckt CONV21_0 DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1258_1400# DCDC_CONV2TO1_0_1650326046_0/m1_3236_3332#
+ VSUBS DCDC_CONV2TO1_0_1650326046_0/m1_140_1652# DCDC_CONV2TO1_0_1650326046_0/m1_54_3332#
+ DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1086_1316# DCDC_CONV2TO1_0_1650326046_0/m1_1172_2072#
+ DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1258_1400# DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046_0/li_1695_151# DCDC_CONV2TO1_0_1650326046_0/m1_3150_1652#
XDCDC_CONV2TO1_0_1650326046_0 DCDC_CONV2TO1_0_1650326046_0/m1_1172_2072# DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046_0/m1_3150_1652# DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046_0/m1_140_1652# DCDC_CONV2TO1_0_1650326046_0/m1_3236_3332#
+ DCDC_CONV2TO1_0_1650326046_0/m1_54_3332# DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_1/DCDC_XSW_PMOS_0_1650326_40a43b21_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046_0/li_1695_151# DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/DCDC_XSW_NMOS_0_1650326_24c8b01c_0/m1_1376_224#
+ VSUBS DCDC_CONV2TO1_0_1650326046_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f_0/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046
.ends

.subckt DCDC_CONV2TO1 m1_2610_5936# m1_1082_1484# m1_1942_308# VSUBS m1_2438_2240#
+ m1_738_1568# m1_566_5264# m1_910_5180# m2_398_0# m1_0_1736# m1_2610_1400# m2_226_0#
+ m2_3494_0#
XCONV21_0_0 m1_1082_1484# m1_738_1568# m2_3494_0# VSUBS m2_398_0# m2_226_0# m1_910_5180#
+ m1_2438_2240# m1_566_5264# m1_2610_5936# m1_2610_1400# m1_1942_308# m1_0_1736# CONV21_0
.ends

.subckt PMOS_4T_84335382_X3_Y1__f7f60cb8 w_n6_0# a_233_357# a_200_897# a_316_357#
X0 a_316_357# a_200_897# a_233_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt NMOS_4T_23806256_X3_Y1__034001d7 a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt TGATE_26054449_0_165076_0e455568 m1_226_1400# PMOS_4T_84335382_X3_Y1__f7f60cb8_0/w_n6_0#
+ m1_140_1316# PMOS_4T_84335382_X3_Y1__f7f60cb8_0/a_200_897# NMOS_4T_23806256_X3_Y1__034001d7_0/a_200_897#
+ VSUBS
XPMOS_4T_84335382_X3_Y1__f7f60cb8_0 PMOS_4T_84335382_X3_Y1__f7f60cb8_0/w_n6_0# m1_226_1400#
+ PMOS_4T_84335382_X3_Y1__f7f60cb8_0/a_200_897# m1_140_1316# PMOS_4T_84335382_X3_Y1__f7f60cb8
XNMOS_4T_23806256_X3_Y1__034001d7_0 m1_226_1400# NMOS_4T_23806256_X3_Y1__034001d7_0/a_200_897#
+ VSUBS m1_140_1316# NMOS_4T_23806256_X3_Y1__034001d7
.ends

.subckt DCDC_MUX_TGATE_0_165076_add9839a TGATE_26054449_0_165076_0e455568_0/PMOS_4T_84335382_X3_Y1__f7f60cb8_0/w_n6_0#
+ TGATE_26054449_0_165076_0e455568_0/m1_140_1316# TGATE_26054449_0_165076_0e455568_0/m1_226_1400#
+ TGATE_26054449_0_165076_0e455568_0/PMOS_4T_84335382_X3_Y1__f7f60cb8_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568_0/NMOS_4T_23806256_X3_Y1__034001d7_0/a_200_897#
+ VSUBS
XTGATE_26054449_0_165076_0e455568_0 TGATE_26054449_0_165076_0e455568_0/m1_226_1400#
+ TGATE_26054449_0_165076_0e455568_0/PMOS_4T_84335382_X3_Y1__f7f60cb8_0/w_n6_0# TGATE_26054449_0_165076_0e455568_0/m1_140_1316#
+ TGATE_26054449_0_165076_0e455568_0/PMOS_4T_84335382_X3_Y1__f7f60cb8_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568_0/NMOS_4T_23806256_X3_Y1__034001d7_0/a_200_897#
+ VSUBS TGATE_26054449_0_165076_0e455568
.ends

.subckt PMOS_4T_84335382_X3_Y1__e3cfcdb4 a_233_357# a_200_897# w_0_0# a_316_357#
X0 a_316_357# a_200_897# a_233_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt DCDC_MUX_PMOS_0_1650762_3e78fab9 li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4_0/a_200_897#
+ PMOS_4T_84335382_X3_Y1__e3cfcdb4_1/a_200_897# m1_602_140# li_921_1243#
XPMOS_4T_84335382_X3_Y1__e3cfcdb4_0 li_921_1243# PMOS_4T_84335382_X3_Y1__e3cfcdb4_0/a_200_897#
+ m1_602_140# li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4
XPMOS_4T_84335382_X3_Y1__e3cfcdb4_1 li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4_1/a_200_897#
+ m1_602_140# li_921_1243# PMOS_4T_84335382_X3_Y1__e3cfcdb4
.ends

.subckt NMOS_4T_64195651_X1_Y1__33ea6cae a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=5.565e+11p pd=4.73e+06u as=5.565e+11p ps=4.73e+06u w=2.1e+06u l=150000u
.ends

.subckt PMOS_4T_13050553_X2_Y1__9ce07c45 a_230_357# a_200_252# a_147_357# w_0_0#
X0 a_230_357# a_200_252# a_147_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.113e+12p pd=9.46e+06u as=1.113e+12p ps=9.46e+06u w=2.1e+06u l=150000u
X1 a_147_357# a_200_252# a_230_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt SKY130_FD_SC_HD__INV_4__a334a03f PMOS_4T_13050553_X2_Y1__9ce07c45_0/a_147_357#
+ PMOS_4T_13050553_X2_Y1__9ce07c45_0/w_0_0# m1_430_896# NMOS_4T_64195651_X1_Y1__33ea6cae_0/a_316_357#
+ m1_430_56# VSUBS
XNMOS_4T_64195651_X1_Y1__33ea6cae_0 m1_430_56# m1_430_896# VSUBS NMOS_4T_64195651_X1_Y1__33ea6cae_0/a_316_357#
+ NMOS_4T_64195651_X1_Y1__33ea6cae
XPMOS_4T_13050553_X2_Y1__9ce07c45_0 m1_430_56# m1_430_896# PMOS_4T_13050553_X2_Y1__9ce07c45_0/a_147_357#
+ PMOS_4T_13050553_X2_Y1__9ce07c45_0/w_0_0# PMOS_4T_13050553_X2_Y1__9ce07c45
.ends

.subckt NMOS_4T_23806256_X3_Y1__7b841cd5 a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt DCDC_MUX_NMOS_0_1650762_762dd4dc NMOS_4T_23806256_X3_Y1__7b841cd5_0/a_200_897#
+ NMOS_4T_23806256_X3_Y1__7b841cd5_1/a_200_897# li_749_1327# li_921_1243# VSUBS
XNMOS_4T_23806256_X3_Y1__7b841cd5_0 li_921_1243# NMOS_4T_23806256_X3_Y1__7b841cd5_0/a_200_897#
+ VSUBS li_749_1327# NMOS_4T_23806256_X3_Y1__7b841cd5
XNMOS_4T_23806256_X3_Y1__7b841cd5_1 li_749_1327# NMOS_4T_23806256_X3_Y1__7b841cd5_1/a_200_897#
+ VSUBS li_921_1243# NMOS_4T_23806256_X3_Y1__7b841cd5
.ends

.subckt DCDC_MUX_0_1650762210 li_2555_3091# m1_2806_560# m1_312_560# m1_828_140# m1_656_2996#
+ li_921_2839# VSUBS
XDCDC_MUX_TGATE_0_165076_add9839a_0 m1_828_140# m1_656_2996# li_921_2839# li_491_1411#
+ m1_312_560# VSUBS DCDC_MUX_TGATE_0_165076_add9839a
XDCDC_MUX_TGATE_0_165076_add9839a_1 m1_828_140# m1_656_2996# li_2555_3091# m1_2806_560#
+ m1_2322_3920# VSUBS DCDC_MUX_TGATE_0_165076_add9839a
XDCDC_MUX_PMOS_0_1650762_3e78fab9_0 m1_828_140# m1_2322_3920# m1_2322_3920# m1_828_140#
+ li_2555_3091# DCDC_MUX_PMOS_0_1650762_3e78fab9
XSKY130_FD_SC_HD__INV_4__a334a03f_0 m1_828_140# m1_828_140# m1_312_560# VSUBS li_491_1411#
+ VSUBS SKY130_FD_SC_HD__INV_4__a334a03f
XSKY130_FD_SC_HD__INV_4__a334a03f_1 m1_828_140# m1_828_140# m1_2806_560# VSUBS m1_2322_3920#
+ VSUBS SKY130_FD_SC_HD__INV_4__a334a03f
XDCDC_MUX_NMOS_0_1650762_762dd4dc_0 li_491_1411# li_491_1411# VSUBS li_921_2839# VSUBS
+ DCDC_MUX_NMOS_0_1650762_762dd4dc
.ends

.subckt DCDC_MUX m2_427_0# m1_336_3180# m1_2572_3264# m1_2658_240# m1_3002_660# m2_2834_0#
+ VSUBS
XDCDC_MUX_0_1650762210_0 m1_2572_3264# m1_3002_660# m2_427_0# m1_2658_240# m2_2834_0#
+ m1_336_3180# VSUBS DCDC_MUX_0_1650762210
.ends

.subckt six_stage_conv clk0b clk1b clk1 clk0 SEL_L[0] SEL_H[0] SEL_L[1] SEL_H[1] SEL_L[2]
+ SEL_H[2] SEL_L[3] SEL_H[3] SEL_L[4] SEL_H[4] SEL_L[5] SEL_H[5] VOUT VPWR VGND
XDCDC_CAP_UNIT_6628 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6617 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6606 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6639 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5916 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5905 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5927 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5949 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5938 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_34 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_23 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_12 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_56 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_45 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_78 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_67 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_89 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2170 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2181 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2192 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1491 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1480 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_130 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_152 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_174 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_163 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_141 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_196 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_185 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7104 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7126 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7115 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6425 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6436 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6414 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6403 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5713 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5702 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5724 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6469 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6458 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6447 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5735 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5746 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5757 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5768 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5779 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_506 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_517 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_528 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6970 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6981 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6992 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5009 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4308 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3607 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4319 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3618 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3629 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2906 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2917 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2939 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2928 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6200 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6211 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6233 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6222 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6244 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6277 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5532 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5510 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6255 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6266 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5521 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5576 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5565 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5554 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4820 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4831 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5543 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6299 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6288 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4853 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4864 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4842 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5598 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5587 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4875 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4886 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4897 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_325 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_303 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_314 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_336 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_347 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_358 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_369 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4105 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4127 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4116 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3415 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3404 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4149 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4138 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2703 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3448 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3437 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3426 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2736 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2747 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2714 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2725 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3459 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2769 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2758 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_718 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_729 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_707 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6052 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6041 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6030 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6074 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6085 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6063 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5351 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5340 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6096 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5362 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5373 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5384 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5395 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4672 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4650 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4661 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_100 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3971 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3960 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4694 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4683 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_133 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_122 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_111 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3993 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3982 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_166 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_144 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_155 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_188 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_177 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_199 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_1309 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_1 SEL_L[1] DCDC_MUX_1/m1_336_3180# DCDC_MUX_1/m1_2572_3264# VPWR SEL_H[1]
+ DCDC_MUX_1/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3223 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3212 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3201 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2522 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3245 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3234 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2500 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2511 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3256 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2533 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3289 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3267 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3278 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2555 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2544 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1810 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2577 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2588 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2566 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1821 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1832 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1843 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2599 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1887 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1854 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1865 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1876 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1898 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_504 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_515 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_548 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_537 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_526 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_559 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5181 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5192 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5170 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4480 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4491 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3790 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1106 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1117 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1128 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1139 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3020 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3031 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2330 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3064 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3042 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3053 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3075 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3097 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2352 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2341 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2363 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3086 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2374 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2396 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2385 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1651 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1662 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1640 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1673 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1695 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1684 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_301 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_323 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_312 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_345 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_356 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_334 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_367 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_378 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_389 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6607 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6618 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6629 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5906 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5917 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5928 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5939 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_890 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_35 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_24 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_13 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_57 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_46 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_68 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_79 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2160 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2171 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2193 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2182 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1470 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1492 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1481 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_131 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_120 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_153 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_164 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_142 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_175 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_186 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_197 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7105 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7127 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7116 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6426 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6415 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6404 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5703 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5714 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5725 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6459 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6448 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6437 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5736 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5758 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5747 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5769 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_507 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_518 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_529 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6960 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6971 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6982 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6993 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4309 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3608 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3619 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2918 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2907 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2929 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6201 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6212 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6223 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6234 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5500 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6278 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5522 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5533 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5511 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6245 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6256 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6267 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5566 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5555 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4821 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5544 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4810 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6289 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4854 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4832 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4865 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4843 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5577 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5599 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5588 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4876 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4887 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4898 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_304 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_315 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_326 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_337 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_348 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_359 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6790 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4106 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4117 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3405 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4128 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4139 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2704 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3438 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3449 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3427 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3416 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2737 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2715 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2726 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2748 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2759 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_719 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_708 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6042 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6053 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6031 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6020 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6075 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6064 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6086 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5341 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5330 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6097 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4640 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5374 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5352 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5363 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5396 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4662 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4651 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4673 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5385 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3961 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3950 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4695 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4684 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_134 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_112 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_101 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_123 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3983 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3994 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3972 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_167 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_156 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_145 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_178 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_189 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_MUX_2 SEL_L[2] DCDC_MUX_3/m1_336_3180# DCDC_MUX_3/m1_2572_3264# VPWR SEL_H[2]
+ DCDC_MUX_3/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3202 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3213 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3224 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3246 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3235 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2512 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2501 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3257 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2523 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2534 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3268 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3279 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2545 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1811 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1800 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2556 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2578 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2567 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2589 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1822 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1833 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1844 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1855 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1866 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1877 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1899 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1888 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_505 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_516 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_538 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_527 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_549 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5193 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5160 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5171 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5182 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4470 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4481 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3780 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4492 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3791 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1129 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1118 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1107 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3021 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3010 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3032 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2320 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3054 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3043 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3065 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3098 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2364 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2353 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2342 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2331 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3076 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3087 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2375 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2397 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2386 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1630 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1652 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1641 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1674 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1685 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1663 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1696 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_302 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_313 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_346 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_324 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_335 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_379 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_368 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_357 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6619 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6608 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5907 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5929 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5918 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_0 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_880 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_891 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_25 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_14 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_58 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_47 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_69 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_36 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2161 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2150 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2172 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2194 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1460 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2183 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1493 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1482 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1471 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_121 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_110 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_154 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_165 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_132 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_143 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_187 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_198 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_176 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7128 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7117 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7106 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6416 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6427 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6405 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5704 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5715 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6449 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6438 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5726 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5737 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5748 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5759 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_508 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_519 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6961 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6950 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6972 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6983 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6994 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1290 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3609 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2919 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2908 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6202 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6213 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6224 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6235 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5523 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5512 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6246 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6257 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6268 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5501 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6279 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4822 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5567 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5556 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5545 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5534 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4800 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4811 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4844 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4855 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4833 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5578 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5589 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4866 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4877 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4888 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_316 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_305 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4899 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_327 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_349 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_338 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6791 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6780 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4107 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4118 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3406 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4129 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3439 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3428 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3417 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2738 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2705 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2716 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2727 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2749 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_709 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6010 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6043 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6032 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6021 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6054 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6065 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6076 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5342 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5331 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5320 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6098 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6087 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5364 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4630 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5375 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5353 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5397 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5386 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4663 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4652 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4641 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3962 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3951 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3940 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4674 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4696 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4685 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_113 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_124 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_102 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3984 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3995 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3973 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_146 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_157 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_135 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_168 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_179 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_MUX_3 SEL_L[2] DCDC_MUX_3/m1_336_3180# DCDC_MUX_3/m1_2572_3264# VPWR SEL_H[2]
+ DCDC_MUX_3/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3203 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3214 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3236 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3247 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2502 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2513 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3225 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2524 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2535 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3269 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2546 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3258 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1801 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2557 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2579 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2568 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1834 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1823 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1812 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1845 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1856 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1878 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1867 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1889 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_506 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_517 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_539 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_528 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5150 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5161 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5172 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5183 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4460 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4471 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4482 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5194 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3770 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4493 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3792 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3781 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1108 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1119 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3011 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3000 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3022 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3033 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2310 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2321 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3055 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3044 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3066 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3099 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2354 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2343 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2332 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3088 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3077 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2365 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2376 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2387 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1620 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1653 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1631 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1642 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2398 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1686 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1675 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1664 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1697 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_303 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_314 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_347 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_336 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_325 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_369 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_358 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4290 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6609 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5908 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5919 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_1 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_870 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_881 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_892 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_26 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_15 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_59 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_37 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_48 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2151 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2162 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2140 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2195 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2173 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1461 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2184 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1450 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1494 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1483 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1472 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_100 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_122 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_111 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_155 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_133 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_144 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_188 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_177 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_166 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_199 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7129 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7118 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7107 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6417 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6406 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5705 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5716 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6439 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6428 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5727 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5738 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5749 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_509 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6940 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6951 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6962 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6973 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6984 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6995 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1291 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1280 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2909 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6203 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6214 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6225 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5524 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5502 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5513 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6247 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6258 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6269 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6236 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5557 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5546 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5535 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4801 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4812 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4845 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4823 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5568 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4856 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4834 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5579 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4867 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4889 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4878 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_306 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_317 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_328 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_339 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6781 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6770 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6792 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4108 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4119 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3429 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3418 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3407 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2706 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2728 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2717 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2739 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6000 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6044 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6022 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6033 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6011 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6055 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6066 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6077 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5321 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5332 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5310 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6088 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6099 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5343 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4631 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4620 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5354 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5365 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5398 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5376 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4664 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4653 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4642 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5387 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3952 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3930 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3941 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4675 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4686 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4697 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_103 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_114 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_125 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3996 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3985 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3963 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3974 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_147 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_158 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_136 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_169 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_MUX_4 SEL_L[3] DCDC_MUX_5/m1_336_3180# DCDC_MUX_5/m1_2572_3264# VPWR SEL_H[3]
+ DCDC_MUX_5/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3204 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3215 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3248 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2503 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3226 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3237 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2525 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2514 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2536 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3259 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1802 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2547 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2569 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2558 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1835 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1824 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1813 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1846 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1857 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1868 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1879 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_507 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_518 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_529 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5140 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5151 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5173 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5162 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5184 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4461 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4472 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4450 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5195 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4483 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3760 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4494 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3793 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3771 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3782 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1109 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3012 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3001 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3023 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3034 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2300 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2311 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3056 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3045 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2322 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2333 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2355 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2344 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3067 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3089 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3078 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1610 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2366 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2377 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2388 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1632 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1621 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1643 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2399 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1665 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1676 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1654 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1687 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1698 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_304 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_337 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_326 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_315 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_348 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_359 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4280 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4291 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3590 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_90 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_860 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5909 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_2 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_871 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_893 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_882 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_16 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_49 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_38 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_27 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2130 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2163 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2152 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2141 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2196 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2174 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1451 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2185 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1440 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1484 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1473 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1495 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1462 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_101 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_112 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_156 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_145 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_134 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_123 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_167 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_189 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_178 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7119 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7108 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6418 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6407 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5706 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6429 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5717 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5728 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5739 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_690 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6930 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6941 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6952 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6963 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6974 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6985 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6996 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1292 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1281 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1270 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6204 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6215 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6226 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6248 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6259 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6237 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5514 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5503 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5547 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5525 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5536 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5558 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4802 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4813 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5569 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4846 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4835 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4824 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4868 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4857 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4879 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_307 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_318 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_329 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6782 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6771 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6760 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6793 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4109 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3419 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3408 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2729 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2707 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2718 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6001 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6023 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6034 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6012 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6067 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6056 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6045 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5322 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5333 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5311 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5300 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6089 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6078 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4610 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4621 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5366 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5344 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5355 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5399 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4643 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4654 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4632 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5377 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5388 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3953 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3931 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3920 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3942 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4676 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4665 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4687 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4698 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_115 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_104 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3986 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3975 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3964 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_148 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_126 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_137 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3997 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_159 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6590 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_5 SEL_L[3] DCDC_MUX_5/m1_336_3180# DCDC_MUX_5/m1_2572_3264# VPWR SEL_H[3]
+ DCDC_MUX_5/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3205 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2504 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3227 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3238 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3216 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2526 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2537 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2515 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3249 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2548 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2559 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1825 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1814 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1803 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1836 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1858 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1847 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1869 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_519 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_508 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5130 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5141 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5152 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5174 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5163 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4462 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4440 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4473 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4451 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5196 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5185 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4484 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3761 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3750 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4495 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3794 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3772 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3783 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_490 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3002 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3013 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3035 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3024 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2301 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2312 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3057 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3046 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2323 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2334 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2345 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3068 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3079 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1600 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2356 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2367 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2378 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1633 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1622 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1644 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1611 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2389 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1666 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1677 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1655 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1688 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1699 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_305 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_338 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_327 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_316 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_349 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4270 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4281 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4292 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3591 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3580 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2890 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_80 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_91 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_850 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_3 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_894 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_872 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_861 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_883 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_17 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_39 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_28 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2120 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2153 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2142 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2131 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2197 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2164 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2175 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1430 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2186 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1452 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1441 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1485 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1463 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1474 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1496 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_102 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_113 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_146 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_124 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_135 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_168 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_179 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_157 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7109 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6408 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5707 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6419 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5718 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5729 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_691 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_680 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6931 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6920 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6942 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6953 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6964 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6975 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6986 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6997 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1260 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1293 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1271 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1282 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6205 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6216 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6227 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6249 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6238 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5515 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5504 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5537 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5548 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5526 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4803 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4836 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4825 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4847 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5559 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4814 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4858 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4869 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_319 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_308 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6750 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6772 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6761 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6794 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6783 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1090 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3409 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2708 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2719 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6002 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6024 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6035 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6013 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6046 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6068 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6057 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5323 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5301 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5312 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6079 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5334 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4622 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4611 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4600 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5345 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5356 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3910 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4655 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4633 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4644 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5367 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5389 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5378 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3921 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3932 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3943 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4666 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4677 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4688 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_116 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_105 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3987 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3965 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3976 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3954 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4699 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_149 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_138 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_127 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3998 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6580 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6591 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5890 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_6 SEL_L[4] DCDC_MUX_7/m1_336_3180# DCDC_MUX_7/m1_2572_3264# VPWR SEL_H[4]
+ DCDC_MUX_7/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3206 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3228 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3239 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3217 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2527 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2516 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2505 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2549 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2538 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1815 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1826 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1804 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1837 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1848 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1859 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_509 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5131 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5120 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4430 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5164 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5142 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5153 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5175 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4463 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4441 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4452 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5197 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5186 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4474 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4485 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3751 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3740 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4496 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3795 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3784 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3773 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3762 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_480 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_491 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3014 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3003 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3036 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3025 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2302 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3047 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2324 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2335 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2313 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2346 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3069 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3058 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1601 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2357 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2368 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2379 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1634 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1623 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1612 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1667 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1656 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1645 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1689 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1678 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_306 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_317 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_328 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_339 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4260 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4271 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3570 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4282 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4293 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3592 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3581 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2880 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2891 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_70 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_81 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_92 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_840 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_851 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_862 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_873 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_884 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_4 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_895 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_29 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_18 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2121 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2110 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2154 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2143 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2132 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2187 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2176 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2165 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1431 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1420 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1442 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2198 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1486 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1453 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1464 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1475 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1497 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_103 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_147 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_114 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_136 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_125 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_158 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_169 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4090 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6409 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5708 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5719 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_670 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_681 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_692 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6910 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6921 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6943 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6932 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6954 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6965 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6987 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6976 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6998 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1250 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1272 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1294 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1261 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1283 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6206 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6217 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6228 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6239 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5505 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5538 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5549 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5527 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4804 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5516 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4837 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4826 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4815 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4859 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4848 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_309 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6773 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6751 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6762 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6740 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6795 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6784 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1091 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1080 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2709 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6003 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6025 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6014 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6047 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6058 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6036 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5324 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5302 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5313 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6069 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5357 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5335 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4612 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4601 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5346 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3900 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4634 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4645 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4623 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5379 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5368 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3911 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3933 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3944 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3922 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4678 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4667 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4656 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4689 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_106 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3977 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3966 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3955 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_117 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_139 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_128 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3999 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3988 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6570 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6581 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6592 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5891 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5880 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_7 SEL_L[4] DCDC_MUX_7/m1_336_3180# DCDC_MUX_7/m1_2572_3264# VPWR SEL_H[4]
+ DCDC_MUX_7/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3229 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3218 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3207 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2506 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2528 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2517 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2539 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1816 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1805 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1827 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1838 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1849 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5132 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5110 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5121 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4420 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5143 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5165 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5154 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4464 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4442 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4453 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4431 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5198 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5176 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5187 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4475 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4486 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3730 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3752 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3741 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4497 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3774 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3763 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3785 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3796 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7090 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_470 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_492 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_481 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3004 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3037 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3026 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3015 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2303 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3048 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2336 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2314 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2325 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3059 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2358 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2369 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2347 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1624 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1635 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1602 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1613 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1668 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1657 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1646 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1679 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_307 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_318 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_329 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4261 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4250 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4272 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3560 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4294 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4283 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3571 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3593 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3582 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2870 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2881 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2892 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_71 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_60 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_82 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_93 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_830 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_841 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_852 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_863 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_874 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_885 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_5 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_896 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_19 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2100 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2111 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2144 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2133 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2122 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2188 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2177 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2155 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2166 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1432 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1421 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1410 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1443 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2199 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1476 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1465 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1454 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1498 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1487 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_104 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_115 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_137 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_126 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_148 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_159 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4080 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4091 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3390 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5709 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_660 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_693 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_682 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_671 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6900 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6911 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6922 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6944 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6933 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6955 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6966 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6977 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6988 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6999 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1251 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1240 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1273 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1284 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1262 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1295 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6207 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6218 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6229 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5506 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5539 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5528 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5517 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4838 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4827 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4816 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4805 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_490 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4849 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6730 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6763 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6752 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6741 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6796 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6774 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6785 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1081 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1092 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1070 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6004 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6015 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6026 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6048 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6059 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6037 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5303 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5314 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5336 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5325 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4613 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4602 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5347 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5358 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3901 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4646 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4635 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4624 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5369 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3912 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3934 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3923 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4668 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4657 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4679 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_107 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3978 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3956 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3967 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3945 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_118 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_129 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3989 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6571 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6560 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6582 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5870 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6593 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5892 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5881 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_8 SEL_L[5] DCDC_MUX_9/m1_336_3180# DCDC_MUX_9/m1_2572_3264# VPWR SEL_H[5]
+ DCDC_MUX_9/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3208 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3219 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2507 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2518 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2529 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1817 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1806 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1828 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1839 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5111 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5122 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5100 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4410 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4421 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5133 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5144 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5166 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5155 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4432 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4454 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4443 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5177 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5199 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5188 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4465 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4476 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4487 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3720 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3742 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3731 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3786 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3764 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3775 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3753 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4498 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3797 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7080 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7091 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6390 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_460 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_471 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_493 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_482 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3005 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3016 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3038 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3027 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2315 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2304 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2337 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2326 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3049 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2348 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2359 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1625 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1603 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1614 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1647 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1658 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1636 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1669 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_308 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_319 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4262 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4240 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4251 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3550 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3561 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4273 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4295 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4284 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3594 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3572 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3583 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_50 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2871 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2882 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2860 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_72 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_61 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_83 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2893 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_94 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_820 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_842 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_831 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_864 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_853 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_875 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_6 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_897 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_886 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_290 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2101 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2145 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1400 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2134 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2123 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2112 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2156 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2178 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2167 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1422 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1411 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1433 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2189 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1444 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1477 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1466 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1455 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1499 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1488 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_127 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_138 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_116 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_105 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_149 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4070 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4092 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4081 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3391 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3380 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2690 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_650 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_683 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_661 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_672 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_694 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6901 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6912 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6945 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6956 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6923 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6934 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6967 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6978 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6989 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1230 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1241 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1252 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1274 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1285 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1263 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1296 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6208 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6219 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5529 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5507 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5518 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4828 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4817 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_491 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_480 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4806 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4839 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6720 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6753 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6764 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6742 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6731 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6797 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6775 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6786 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1060 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1082 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1093 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1071 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6005 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6016 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6049 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6038 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6027 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5304 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5315 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5337 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5326 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4603 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5348 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4636 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4625 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4614 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5359 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3902 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3913 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3935 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3924 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4669 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4647 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4658 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3957 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3946 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3968 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_119 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_108 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3979 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6572 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6550 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6561 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5860 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6583 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6594 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5882 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5871 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5893 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_9 SEL_L[5] DCDC_MUX_9/m1_336_3180# DCDC_MUX_9/m1_2572_3264# VPWR SEL_H[5]
+ DCDC_MUX_9/m2_2834_0# VGND DCDC_MUX
XDCDC_CAP_UNIT_3209 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2508 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2519 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1807 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1818 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1829 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5112 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5123 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5101 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4400 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4411 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5134 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5156 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5145 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4433 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4455 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4444 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4422 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3710 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5167 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5189 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5178 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4466 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4477 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4488 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3721 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3743 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3732 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3765 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3776 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3754 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4499 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3798 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3787 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7081 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7092 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7070 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6380 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6391 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5690 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_461 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_450 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_472 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_494 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_483 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3006 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3017 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3039 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3028 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2305 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2327 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2316 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2338 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2349 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1626 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1615 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1604 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1648 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1659 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1637 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_309 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4230 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4263 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4241 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4252 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3551 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3540 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4274 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4296 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4285 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2850 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3573 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3562 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3584 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_40 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2883 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2861 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2872 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3595 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_73 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_62 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_84 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_51 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2894 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_95 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_821 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_832 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_810 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_843 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_865 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_876 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_854 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_7 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_887 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_898 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_291 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_280 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2102 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2135 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2113 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2124 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2157 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2146 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2168 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1412 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2179 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1423 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1401 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1434 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1445 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1467 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1456 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1489 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1478 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_128 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_117 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_106 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_139 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4060 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4071 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4093 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4082 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3370 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3392 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3381 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2691 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2680 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1990 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_651 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_640 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_662 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_684 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_673 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_695 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6902 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6913 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6946 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6935 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6924 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6968 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6957 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6979 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1242 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1220 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1231 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1253 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1275 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1264 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1297 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1286 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6209 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5508 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5519 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4829 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4818 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_492 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_481 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_470 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4807 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6721 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6710 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6754 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6743 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6732 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6776 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6765 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6787 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6798 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1050 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1061 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1072 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1083 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1094 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6006 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6017 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6039 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6028 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5305 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5338 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5327 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5316 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4604 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4637 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4626 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4615 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5349 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3903 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3925 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3914 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4659 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4648 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3958 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3947 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3969 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3936 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_109 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6540 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6562 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6551 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6573 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6584 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6595 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5850 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5861 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5872 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5894 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5883 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2509 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1808 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1819 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5113 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5102 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4412 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4401 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5124 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5157 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5146 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5135 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4434 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4445 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3700 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4423 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5168 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5179 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4467 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4456 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4478 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3722 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3711 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3733 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4489 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3766 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3777 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3744 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3755 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3788 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3799 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7082 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7071 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7060 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7093 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6381 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6370 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6392 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5691 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5680 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4990 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_440 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_462 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_451 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_473 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_484 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_495 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3018 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3029 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3007 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2306 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2328 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2317 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2339 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1605 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1616 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1627 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1649 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1638 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4220 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4253 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4242 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4231 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3552 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3541 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3530 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4275 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4264 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4297 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4286 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2840 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3585 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3574 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3563 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_30 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_41 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2862 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2873 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2851 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3596 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_63 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_74 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_52 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2895 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2884 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_96 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_85 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_800 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_811 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_833 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_822 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_866 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_855 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_844 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_8 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_888 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_877 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_899 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_270 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_281 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_292 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2136 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2125 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2103 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2114 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2158 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2147 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2169 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1413 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1424 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1402 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1446 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1468 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1435 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1457 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1479 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_107 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_118 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_129 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4050 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4061 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4094 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4083 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3360 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4072 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3382 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3371 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3393 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2670 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2692 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2681 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1980 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1991 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_630 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_641 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_652 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_663 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_674 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_696 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_685 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6903 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6947 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6914 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6936 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6925 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6958 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6969 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1221 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1232 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1210 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1276 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1254 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1265 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1243 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1287 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1298 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3190 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5509 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4819 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4808 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_493 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_482 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_471 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_460 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6711 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6700 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6755 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6744 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6722 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6733 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6766 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6777 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6788 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6799 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1040 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1051 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1062 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1073 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1084 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1095 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6007 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6029 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6018 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5306 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5339 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5328 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5317 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_290 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4616 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4627 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4605 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3904 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3926 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3915 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4638 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4649 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3959 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3948 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3937 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6530 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6552 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6541 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6563 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6596 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6574 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5851 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5840 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6585 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5884 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5895 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5873 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5862 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1809 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5114 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5103 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4402 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5125 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5136 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5147 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4413 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4435 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4446 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3701 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4424 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5158 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5169 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4468 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4457 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4479 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3712 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3723 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3734 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3767 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3745 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3756 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3789 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3778 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7083 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7072 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7061 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7050 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7094 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6360 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6371 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5670 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6393 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6382 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5692 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5681 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4991 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4980 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_441 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_430 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_452 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_463 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_485 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_474 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_496 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3019 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3008 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2307 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2318 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2329 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1617 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1606 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1628 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1639 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4210 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4254 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4243 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4232 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4221 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3542 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3531 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3520 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4265 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4276 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4287 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2830 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2841 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3553 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3564 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3575 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4298 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_20 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_31 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2874 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2863 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2852 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3586 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3597 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_64 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_75 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_53 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_42 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2896 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2885 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_97 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_86 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_812 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_823 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_801 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_834 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_867 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_856 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_845 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_9 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND DCDC_MUX_7/m2_2834_0#
+ DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_878 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_889 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6190 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_260 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_293 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_271 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_282 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2126 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2115 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2104 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2159 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2148 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1414 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1403 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1425 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2137 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1447 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1436 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1458 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1469 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_119 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_108 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4040 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4051 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4062 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3350 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4095 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4084 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4073 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3372 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3394 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3361 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3383 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2671 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2660 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2682 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2693 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1970 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1981 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1992 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_631 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_620 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_642 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_675 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_664 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_653 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_697 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_686 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6904 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6915 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6937 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6926 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6948 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6959 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1200 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1222 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1233 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1211 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1244 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1255 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1266 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1277 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1288 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1299 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3191 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3180 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2490 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_450 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4809 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_483 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_472 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_461 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_494 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6701 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6712 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6745 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6734 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6723 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6789 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6756 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6778 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6767 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1041 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1030 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1063 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1074 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1052 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1096 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1085 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6008 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6019 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5329 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5318 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5307 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_291 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_280 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4628 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4617 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4606 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3905 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3916 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4639 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3949 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3927 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3938 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6520 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6553 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6531 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6542 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6597 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6564 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6575 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5852 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5830 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5841 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6586 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5885 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5874 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5863 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5896 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5104 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4403 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5115 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5126 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5137 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5148 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4436 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4414 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4425 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5159 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4469 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4458 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4447 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3702 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3713 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3724 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3768 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3746 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3735 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3757 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3779 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7040 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7073 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7062 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7051 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7084 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7095 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6361 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6350 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6372 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5660 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6383 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6394 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5693 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5682 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5671 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4970 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4992 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4981 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_420 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_442 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_431 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_453 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_464 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_475 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_486 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_497 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3009 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2308 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2319 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1607 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1629 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1618 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4211 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4200 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4244 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4233 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4222 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3543 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3510 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3532 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3521 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4266 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4255 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4277 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4288 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2820 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2831 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3554 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3565 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3576 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4299 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_21 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_32 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_10 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2842 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2864 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2853 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3587 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3598 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_65 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_54 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_43 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2875 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2897 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2886 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_76 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_87 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_98 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_813 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_802 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_824 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_835 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_857 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_846 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6180 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_879 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_868 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6191 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5490 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_261 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_250 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_283 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_294 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_272 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2127 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2105 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2116 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2149 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1415 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1404 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2138 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1426 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1437 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1459 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1448 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_109 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4041 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4030 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4052 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3340 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4096 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4085 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4074 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3351 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4063 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3373 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3362 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3384 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2650 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2661 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2672 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2683 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3395 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2694 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1971 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1960 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1993 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1982 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_610 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_621 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_632 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_643 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_665 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_654 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_687 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_698 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_676 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6905 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6938 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6916 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6927 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6949 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1223 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1201 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1212 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1256 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1245 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1267 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1234 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1289 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1278 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3181 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3170 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3192 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2491 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2480 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1790 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_440 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_484 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_473 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_462 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_451 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_495 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6702 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6746 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6713 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6735 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6724 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6779 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6768 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6757 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1042 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1020 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1031 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1075 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1064 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1053 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1097 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1086 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6009 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5319 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5308 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_270 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_292 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_281 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4618 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4607 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3906 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3917 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4629 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3928 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3939 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6521 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6510 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6554 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6543 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6532 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6576 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5842 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5831 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5820 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6587 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6565 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6598 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5886 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5875 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5853 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5864 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5897 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5105 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5116 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5127 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5138 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4404 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4415 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4426 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5149 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4459 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4437 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4448 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3714 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3703 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3725 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3758 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3736 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3747 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3769 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7030 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7074 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7063 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7052 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7041 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7085 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7096 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6362 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6340 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6351 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5650 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5661 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6384 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6373 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6395 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5683 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5694 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5672 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4971 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4960 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4982 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_410 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4993 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_421 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_432 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_443 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_465 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_476 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_454 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_498 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_487 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2309 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1608 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1619 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4201 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3500 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4234 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4245 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4223 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4212 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3511 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3522 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3533 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4256 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4267 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4278 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2832 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2810 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2821 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3544 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3555 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3566 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4289 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_22 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_11 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2865 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2843 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2854 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3588 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3599 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3577 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_55 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_66 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_33 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_44 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2898 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2887 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2876 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_77 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_88 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_99 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_814 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_803 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_825 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_836 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_858 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_847 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6170 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_869 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6192 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6181 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5491 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5480 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4790 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_240 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_251 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_262 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_273 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_295 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_284 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2106 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2117 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1405 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1416 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2128 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2139 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1427 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1449 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1438 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4020 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4042 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4031 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4053 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3330 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3341 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4086 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4075 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4064 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2640 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4097 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3374 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3352 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3363 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3385 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2651 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2662 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2673 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3396 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2684 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2695 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1950 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1972 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1961 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1983 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1994 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_611 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_622 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_600 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_633 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_644 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_655 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_666 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_699 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_688 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_677 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6906 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6928 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6917 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6939 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1224 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1213 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1202 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1246 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1257 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1235 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1279 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1268 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3160 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3193 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3171 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3182 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2481 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2470 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2492 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1780 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1791 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_430 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_441 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_463 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_474 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_452 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_496 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_485 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6703 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6725 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6736 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6714 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6747 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6769 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6758 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1010 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1032 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1021 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1065 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1054 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1043 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1098 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1076 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1087 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5309 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_260 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_271 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_282 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4608 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4619 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_293 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3907 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3929 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3918 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6511 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6500 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6544 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6533 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6522 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5810 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6577 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6588 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6555 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6566 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5843 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5821 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5832 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6599 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5865 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5876 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5854 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5887 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5898 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5117 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5128 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5106 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5139 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4405 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4416 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4427 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4438 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4449 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3704 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3715 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3737 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3726 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3759 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3748 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7031 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7020 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7064 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7053 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7042 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7097 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7075 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7086 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6330 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6341 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6363 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6352 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5651 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6374 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6396 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5640 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6385 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5662 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5684 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5673 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4950 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5695 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4983 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4972 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4961 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_400 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4994 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_422 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_433 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_444 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_411 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_455 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_466 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_477 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_488 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_499 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_1609 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4202 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4235 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4224 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4213 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3534 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3523 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3512 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3501 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4257 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4268 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4246 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2822 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2800 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2811 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3545 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3567 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3556 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4279 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_23 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_12 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2833 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2844 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2855 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3589 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3578 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_56 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_34 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_45 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2866 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2899 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2888 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2877 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_89 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_78 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_67 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_815 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_804 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_826 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_837 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_848 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6171 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_859 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6160 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6182 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6193 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5470 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5492 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5481 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4791 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4780 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_230 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_252 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_241 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_263 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_274 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_285 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_296 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2107 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2118 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1406 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2129 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1428 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1417 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1439 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4010 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4021 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4043 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4032 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3342 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3331 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3320 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4087 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4054 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4076 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4065 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2630 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4098 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3353 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3375 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3364 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2663 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2641 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2652 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2674 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3397 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3386 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2696 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2685 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1951 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1940 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1962 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1973 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1995 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1984 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_623 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_601 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_612 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_634 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_645 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_656 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_667 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_689 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_678 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6907 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6929 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6918 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1214 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1203 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1247 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1258 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1225 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1236 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1269 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3150 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3161 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3172 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3183 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2482 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2460 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2471 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3194 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2493 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1770 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1792 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1781 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_431 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_420 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_464 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_442 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_475 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_453 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_497 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_486 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6737 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6704 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6726 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6715 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6759 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6748 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1011 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1033 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1000 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1022 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1044 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1066 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1055 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1088 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1099 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1077 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2290 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_250 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_261 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_272 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_283 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4609 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_294 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3908 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3919 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6512 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6501 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6545 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6534 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6523 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5800 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6567 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6578 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6556 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5833 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5822 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5811 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6589 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5877 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5855 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5866 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5844 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5888 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5899 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5107 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5129 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5118 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4406 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4417 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4439 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3705 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3716 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4428 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3727 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3749 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3738 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7021 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7010 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7065 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7032 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7054 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7043 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6320 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7098 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7076 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7087 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6331 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6342 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6353 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5652 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6364 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6375 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6386 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5630 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5641 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5663 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5685 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5674 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6397 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4940 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5696 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4962 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4973 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4951 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_401 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4995 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4984 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_434 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_423 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_412 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_445 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_456 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_467 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_489 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_478 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4225 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4236 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4203 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4214 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3502 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3513 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3524 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4269 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4258 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4247 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2823 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2801 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2812 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3546 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3535 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3557 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_13 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2834 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2845 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2856 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3568 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3579 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_57 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_46 DCDC_MUX_0/m1_336_3180# DCDC_CONV2TO1_66/m1_1082_1484# VPWR VGND
+ DCDC_MUX_1/m2_2834_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT_7130/m3_72_0#
+ DCDC_CAP_UNIT_7131/m3_72_0# clk1b clk0b DCDC_MUX_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_24 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_35 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2867 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2889 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2878 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_79 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_68 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_805 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_816 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_827 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_838 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_849 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6161 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6150 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6194 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6183 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6172 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5460 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5482 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5471 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5493 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4770 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4792 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4781 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_242 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_231 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_220 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_264 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_275 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_253 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_286 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_297 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2108 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1407 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2119 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1429 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1418 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4000 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4011 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4022 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4033 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4044 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3321 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3310 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3332 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4055 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4066 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4077 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2631 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2620 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3343 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4099 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4088 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3354 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3365 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3376 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2653 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2664 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2642 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3387 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3398 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2697 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2686 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2675 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1963 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1952 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1930 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1941 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1985 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1974 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1996 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_602 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_624 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_613 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_635 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_646 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_657 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_679 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_668 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5290 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6908 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6919 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1204 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1215 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1248 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1226 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1237 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1259 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3151 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3140 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3162 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3173 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3184 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2450 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2461 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2472 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3195 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2494 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2483 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1771 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1760 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1782 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1793 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_421 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_432 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_410 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_465 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_443 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_454 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_498 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_487 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_476 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6705 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6727 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6716 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6749 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6738 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1012 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1001 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1023 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1045 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1056 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1034 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1078 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1089 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1067 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2280 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2291 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1590 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_240 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_251 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_262 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_273 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_295 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_284 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3909 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6502 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6535 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6524 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6513 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5801 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6557 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6568 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6579 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5834 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6546 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5823 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5812 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5856 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5867 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5845 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5878 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5889 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5108 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5119 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4407 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4418 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3706 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4429 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3717 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3728 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3739 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7000 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7022 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7011 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7033 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7055 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7044 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6310 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7077 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7088 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7066 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6321 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6332 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6343 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6354 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5620 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7099 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6365 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6387 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5631 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5642 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6376 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5653 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5664 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6398 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5675 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4930 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4941 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5697 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5686 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4963 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4974 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4952 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4985 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4996 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_435 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_424 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_402 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_413 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_457 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_446 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_468 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_479 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4215 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4226 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4204 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3503 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3514 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3525 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4259 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4237 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4248 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2813 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2802 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3547 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3536 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3558 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_14 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2824 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2835 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2846 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3569 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_25 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_36 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_47 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2868 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2857 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2879 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_58 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_69 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_806 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_817 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_839 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_828 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6151 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6140 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6162 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6195 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6184 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6173 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5450 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5483 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5461 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5494 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5472 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4782 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4760 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4771 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4793 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_221 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_210 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_243 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_232 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_265 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_276 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_254 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_298 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_287 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2109 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1408 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1419 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4001 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4012 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3300 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4023 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4034 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3333 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3322 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3311 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4078 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4056 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4067 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4045 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2610 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2621 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3344 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4089 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3355 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3366 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2632 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2665 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2643 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2654 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3388 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3377 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3399 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1920 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2687 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2698 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2676 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1953 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1942 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1931 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1964 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1986 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1975 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1997 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_614 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_603 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_625 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_636 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_647 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_658 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_669 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5291 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5280 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4590 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6909 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1205 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1249 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1227 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1238 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1216 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3130 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3141 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3152 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3163 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3174 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2451 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2462 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2440 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2473 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3196 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3185 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2495 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2484 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1761 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1750 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1783 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1794 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1772 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_400 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_422 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_411 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_466 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_455 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_444 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_433 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_499 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_488 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_477 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6706 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6728 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6717 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6739 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1002 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1013 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1024 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1046 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1035 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1057 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1079 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1068 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2281 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2270 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2292 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1580 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1591 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_230 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_263 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_274 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_252 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_241 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_296 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_285 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6503 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6514 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6536 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6525 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6569 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6558 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6547 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5824 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5802 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5813 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5857 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5868 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5835 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5846 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5879 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5109 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4408 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4419 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3707 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3718 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3729 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7001 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7012 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7034 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7056 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7023 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7045 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6311 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6300 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7078 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7089 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7067 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6322 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6333 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6344 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5621 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6355 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6366 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5632 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5643 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5610 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6377 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5654 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4931 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5665 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6399 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6388 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5676 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4920 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5698 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5687 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4953 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4964 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4942 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4986 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4997 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4975 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_425 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_403 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_414 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_458 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_447 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_436 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_469 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4216 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4227 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4205 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3515 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3504 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4238 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4249 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2814 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2803 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3537 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3548 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3526 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2825 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2836 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2847 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3559 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_26 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_15 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_48 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_37 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2869 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2858 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_59 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_829 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_807 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_818 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6130 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6152 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6141 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6196 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6174 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5440 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6185 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6163 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5451 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5484 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5462 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5473 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4750 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5495 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4783 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4761 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4772 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_200 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4794 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_222 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_233 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_211 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_244 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_255 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_277 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_266 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_299 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_288 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_1409 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4002 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4013 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4024 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4035 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3323 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3301 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3312 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4057 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4068 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4046 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2600 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2611 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2622 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3334 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3345 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4079 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3356 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3367 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2644 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2655 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2633 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1910 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3389 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3378 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2666 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2688 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2677 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1943 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1932 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1954 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1921 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2699 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1965 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1976 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1987 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1998 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_604 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_615 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_626 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_637 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_648 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_659 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5292 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5281 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5270 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4580 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4591 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3890 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1206 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1228 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1217 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1239 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3131 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3120 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3142 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3153 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3164 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2430 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3175 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2452 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2441 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2463 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3197 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3186 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2496 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2485 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2474 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1740 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1762 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1751 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1784 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1795 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1773 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_401 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_423 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_412 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_434 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_456 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_445 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_467 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_489 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_478 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6707 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6718 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6729 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_990 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1014 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1003 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1047 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1036 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1025 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1058 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1069 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2260 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2271 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2293 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2282 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1570 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1592 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1581 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_231 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_220 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_264 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_253 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_242 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_275 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_286 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_297 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6504 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6515 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6526 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6548 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5825 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6537 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5803 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5814 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6559 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5847 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5858 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5836 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5869 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2090 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4409 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3719 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3708 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7002 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7013 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7035 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7024 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7046 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6301 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5600 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7079 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7068 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7057 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6334 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6312 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6323 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6345 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5622 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6356 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6378 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6367 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5633 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5611 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5655 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4921 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5666 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6389 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5644 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4910 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4932 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5688 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5699 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4965 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5677 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4954 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4943 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4998 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4987 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4976 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_426 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_404 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_415 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_437 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_459 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_448 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6890 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4217 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4206 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3505 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3516 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4239 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4228 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2804 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3549 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3538 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3527 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2815 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2826 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2837 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_27 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_16 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_38 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2848 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2859 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_49 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6120 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_808 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_819 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6153 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6142 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6131 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6175 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6186 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5430 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5441 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6164 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6197 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5485 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5452 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4740 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5474 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5463 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4773 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4751 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5496 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4762 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4784 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4795 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_234 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_201 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_212 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_223 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_245 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_256 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_267 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_278 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_289 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4025 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4003 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4014 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3302 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3313 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3324 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4047 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4069 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4058 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4036 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2601 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2612 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3335 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3346 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3357 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2634 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2623 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2656 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2645 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1900 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1911 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3368 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3379 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2667 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2678 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2689 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1944 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1933 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1922 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1955 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1966 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1977 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1999 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1988 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_605 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_627 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_616 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_638 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_649 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5260 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5293 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5282 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5271 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4570 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4581 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3880 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4592 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3891 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1229 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1218 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1207 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3132 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3110 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3121 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3143 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3154 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3165 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2420 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2453 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2442 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2431 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2464 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3187 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3176 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3198 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2497 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2486 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2475 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1741 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1730 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1752 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1796 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1785 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1774 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1763 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_402 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_413 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_457 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_446 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_424 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_435 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_479 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_468 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5090 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6708 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6719 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_991 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_980 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1004 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1015 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1037 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1048 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1026 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1059 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2261 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2250 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2272 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2294 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2283 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1560 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1571 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1593 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1582 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_221 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_210 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_254 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_265 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_243 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_232 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_276 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_287 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_298 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6505 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6516 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6527 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6549 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6538 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5804 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5815 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5837 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5848 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5859 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5826 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2080 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2091 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1390 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3709 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7003 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7036 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7025 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7047 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7014 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6302 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7069 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7058 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6335 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6313 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6324 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5623 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5601 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6357 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6368 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5634 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5612 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6346 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5656 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5667 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5645 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6379 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4911 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4900 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4922 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5689 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4955 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5678 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4944 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4933 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4999 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4988 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4966 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4977 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_405 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_416 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_438 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_427 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_449 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6891 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6880 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4218 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4207 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3506 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4229 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2805 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3539 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3528 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3517 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2816 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2827 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2838 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_17 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_28 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_39 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2849 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6110 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_809 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6121 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6143 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6132 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6187 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6165 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5431 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6176 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5442 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5420 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6154 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6198 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5453 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4730 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5475 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5464 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4752 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4741 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5497 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5486 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4763 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4785 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4774 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4796 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_213 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_202 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_224 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_235 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_246 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_268 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_257 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_279 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4004 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4015 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4026 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3303 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3314 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4048 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4059 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4037 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2602 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2613 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3347 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3336 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3325 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3358 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2635 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2624 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2646 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1901 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3369 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2657 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2668 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2679 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1912 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1934 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1945 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1923 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1956 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1967 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1978 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1989 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_606 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_617 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_628 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_639 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5250 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5261 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5283 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5272 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4571 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5294 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4560 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4582 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3870 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4593 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3881 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3892 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1219 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1208 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3133 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3100 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3122 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3111 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3144 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3166 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3155 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2410 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2421 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2443 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2454 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2432 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3188 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3177 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3199 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2498 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2487 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2465 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2476 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1720 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1742 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1731 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1753 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1786 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1775 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1764 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1797 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_403 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_414 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_425 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_436 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_447 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_469 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_458 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5091 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5080 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4390 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6709 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_970 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_981 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_992 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1005 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1038 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1027 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1016 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1049 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2262 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2251 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2240 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2295 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2284 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2273 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1550 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1561 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1572 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1594 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1583 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_200 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_222 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_211 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_255 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_244 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_233 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_277 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_266 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_288 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_299 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6517 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6506 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6539 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6528 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5816 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5805 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5849 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5827 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5838 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2070 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2081 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2092 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1391 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1380 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7004 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7037 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7026 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7015 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7059 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7048 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6336 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6325 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6303 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6314 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5624 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5602 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6358 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6347 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5613 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6369 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5657 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4901 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5646 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5635 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4912 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5679 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4956 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4945 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4923 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5668 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4934 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4967 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4989 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4978 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_406 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_417 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_439 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_428 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6870 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6881 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6892 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4208 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3507 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4219 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3518 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3529 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2817 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2806 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2828 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_18 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_29 DCDC_MUX_1/m1_336_3180# DCDC_CONV2TO1_84/m1_1082_1484# VPWR VGND
+ DCDC_MUX_3/m2_2834_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT_7127/m3_72_0#
+ DCDC_CAP_UNIT_7129/m3_72_0# clk1b clk0b DCDC_MUX_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2839 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6100 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6111 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6122 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6144 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6133 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6177 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5432 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5410 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6166 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5421 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6155 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6199 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6188 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5443 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5454 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5465 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4720 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4731 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5476 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4753 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4742 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5498 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5487 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4764 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4786 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4775 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4797 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_214 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_225 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_203 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_236 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_247 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_258 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_269 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4005 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4016 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3304 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3315 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4027 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4049 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4038 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2603 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3348 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3337 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3326 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2614 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2636 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2625 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2647 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1902 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3359 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2658 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2669 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1913 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1924 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1935 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1957 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1946 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1968 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1979 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_607 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_629 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_618 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5240 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5251 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5262 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5284 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5273 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5295 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4561 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4550 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4572 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3871 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3860 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4594 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4583 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3882 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3893 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1209 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3101 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3123 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3112 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3145 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3134 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3156 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2411 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2400 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3167 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2433 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2444 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2422 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2455 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3189 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3178 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1710 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2488 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2477 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2466 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1743 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1721 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1732 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2499 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1787 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1776 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1765 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1754 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1798 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_404 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_437 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_415 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_426 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_448 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_459 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5092 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5081 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5070 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4380 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4391 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3690 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_960 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_971 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_993 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_982 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1006 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1039 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1017 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1028 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2230 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2263 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2252 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2241 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2296 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2285 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2274 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1551 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1540 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1573 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1562 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1595 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1584 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_201 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_212 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_245 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_234 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_256 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_223 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_267 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_278 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_289 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6518 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6507 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6529 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5806 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5828 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5839 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5817 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_790 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2060 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2071 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1370 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2082 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2093 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1392 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1381 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7005 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7038 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7027 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7016 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7049 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6326 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6315 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6304 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5625 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5603 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6348 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6337 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5614 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6359 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5658 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4913 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5647 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5636 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4902 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4946 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4924 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5669 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4935 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4979 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4968 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4957 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_407 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_429 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_418 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6882 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6871 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6860 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6893 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4209 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3519 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3508 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2818 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2807 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2829 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_19 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6101 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6112 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6123 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6134 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6178 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6167 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5433 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5400 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5422 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5411 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6156 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6145 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6189 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5444 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5455 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4721 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4710 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5466 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4754 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4743 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4732 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5477 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5499 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5488 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4787 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4798 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4776 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4765 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_204 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_215 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_237 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_259 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_248 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_226 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6690 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4017 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4006 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3305 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4028 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4039 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2604 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3338 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3327 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3316 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3349 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2615 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2637 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2626 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2648 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2659 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1914 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1903 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1936 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1925 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1947 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1958 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1969 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_608 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_619 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5230 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5241 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5263 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5252 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5274 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4540 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4562 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5296 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4573 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4551 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5285 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3850 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3861 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4584 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4595 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3872 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3883 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3894 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3102 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3124 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3113 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3146 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3135 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3157 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2412 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2401 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3168 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2434 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2423 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2445 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3179 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1700 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2489 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2456 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2467 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2478 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1711 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1722 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1744 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1733 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1777 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1766 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1755 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1799 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1788 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_405 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_427 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_438 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_416 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_449 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5082 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5071 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5060 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4381 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4370 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5093 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4392 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3680 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3691 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2990 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_950 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_961 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_972 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_994 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_983 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1007 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1029 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1018 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2220 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2253 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2242 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2231 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2286 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2297 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2264 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2275 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1541 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1530 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1552 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1563 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1585 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1574 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1596 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_202 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_213 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_246 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_224 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_235 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_279 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_268 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_257 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6508 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6519 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5807 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5829 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5818 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_780 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_791 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2050 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2072 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2061 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1360 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2083 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2094 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1371 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1382 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1393 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7028 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7017 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7006 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7039 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6316 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6327 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6305 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5604 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6338 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6349 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5615 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5648 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5626 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5637 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4903 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5659 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4914 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4947 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4936 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4925 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4969 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4958 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_408 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_419 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6872 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6850 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6861 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6883 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6894 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1190 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3509 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2819 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2808 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6124 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6102 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6135 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6113 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5401 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5412 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6168 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5423 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6157 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6146 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5434 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6179 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5445 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5456 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4722 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4700 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4711 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5467 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5489 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4755 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4744 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4733 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5478 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4777 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4766 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4788 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_216 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_205 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4799 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_238 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_249 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_227 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6680 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6691 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5990 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4007 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3306 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4018 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4029 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3328 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3317 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3339 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2605 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2627 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2638 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2616 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2649 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1915 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1904 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1926 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1948 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1959 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1937 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_609 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5231 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5220 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5253 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5242 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5264 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4530 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5275 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4541 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4563 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5286 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5297 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4552 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3840 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3851 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3862 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4585 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4596 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4574 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3873 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3884 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3895 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3103 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3114 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3147 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3125 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3136 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2402 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3169 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3158 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2435 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2424 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2413 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2446 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1701 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2457 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2479 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2468 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1712 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1723 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1734 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1767 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1778 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1756 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1745 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1789 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_406 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_417 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_439 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_428 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5050 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5083 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5072 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5061 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4360 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4371 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5094 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4393 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4382 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3670 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3681 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3692 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2991 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2980 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_940 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_951 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_962 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_973 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_984 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_995 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1008 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1019 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2210 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2221 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2254 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2243 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2232 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2287 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2265 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2276 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1542 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1531 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1520 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2298 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1564 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1553 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1586 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1575 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1597 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_203 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_225 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_236 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_214 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_247 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_269 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_258 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4190 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6509 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5819 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5808 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_792 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_770 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_781 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2051 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2040 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2062 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1361 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1350 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2073 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2084 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2095 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1372 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1394 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1383 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_0 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7007 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7029 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7018 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6317 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6306 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6328 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5605 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6339 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5616 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5649 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5627 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5638 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4904 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4915 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4926 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4937 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4959 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4948 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_409 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6840 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6873 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6862 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6851 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6884 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6895 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1180 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1191 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2809 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6114 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6103 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6125 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6169 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5402 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5413 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5424 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6136 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6158 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6147 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5435 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5446 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5457 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4701 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4712 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4745 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4723 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4734 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5479 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5468 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4756 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4767 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4778 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4789 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_206 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_228 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_217 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_239 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6670 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6681 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6692 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5980 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5991 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4008 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4019 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3329 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3318 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3307 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2606 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2628 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2617 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2639 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1905 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1916 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1949 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1938 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1927 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5232 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5221 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5210 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5265 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5254 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5243 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4520 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4531 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4542 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5298 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4564 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5287 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5276 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4553 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3841 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3852 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3830 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4586 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4575 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4597 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3863 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3885 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3874 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3896 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3104 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3115 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3137 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3148 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3126 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2403 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3159 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2436 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2414 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2425 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2458 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2447 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2469 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1702 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1724 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1713 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1735 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1768 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1757 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1746 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1779 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_407 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_418 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_429 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5040 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5062 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5051 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5073 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4361 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4350 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4372 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5095 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5084 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4394 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4383 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3660 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3682 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3671 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3693 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2992 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2970 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2981 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_941 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_952 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_930 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_974 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_963 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_985 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_996 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1009 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2200 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2211 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2222 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2244 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1510 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2233 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2288 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2266 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2255 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2277 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1543 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1532 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1521 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2299 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1576 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1565 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1554 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1587 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1598 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_204 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_237 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_226 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_215 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_248 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_259 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4180 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4191 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3490 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_760 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5809 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_793 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_771 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_782 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2063 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2052 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2041 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2030 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1340 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1351 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2074 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2096 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2085 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1373 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1362 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1384 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1395 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7019 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7008 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6318 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6307 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6329 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5606 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5628 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5639 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5617 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4916 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_590 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4927 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4938 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4905 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4949 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6830 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6863 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6852 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6841 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6885 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6874 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6896 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1181 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1170 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1192 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6104 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6126 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6115 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5403 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5414 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6159 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6137 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6148 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5436 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5447 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5425 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5458 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4702 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4713 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4746 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4724 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4735 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5469 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4757 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4768 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4779 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_207 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_229 DCDC_MUX_5/m1_336_3180# DCDC_CONV2TO1_9/m1_1082_1484# VPWR VGND
+ DCDC_MUX_7/m2_2834_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CAP_UNIT_7117/m3_72_0#
+ clk1b clk0b DCDC_MUX_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_218 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6660 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6671 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6682 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5970 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6693 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5992 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5981 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4009 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3308 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3319 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2607 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2629 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2618 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1906 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1917 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1939 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1928 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5211 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5222 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5200 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5255 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5233 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4521 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5244 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4510 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5266 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4532 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4543 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5288 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5277 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5299 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4554 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3853 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3842 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3831 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3820 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4565 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4587 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4576 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3864 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3875 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3886 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4598 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3897 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6490 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3105 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3138 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3127 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3116 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3149 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2426 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2415 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2437 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2404 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2459 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2448 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1703 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1714 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1725 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1736 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1747 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1758 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1769 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_408 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_419 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5030 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5041 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5063 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5052 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5074 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4362 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4351 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4340 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5085 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5096 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4395 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4373 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4384 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3650 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3661 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3672 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3683 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3694 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2993 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2960 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2982 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2971 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_942 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_931 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_920 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_953 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_975 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_964 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_986 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_997 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_390 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2201 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2212 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2245 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2223 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1500 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2234 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2267 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2256 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2278 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1533 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1511 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1522 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2289 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1544 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1577 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1566 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1555 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1599 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1588 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_238 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_205 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_216 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_227 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_249 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4170 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4181 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4192 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3480 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3491 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2790 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_750 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_794 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_761 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_772 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_783 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2020 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2031 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2042 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2053 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1330 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1341 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1352 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2064 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2075 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2086 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1374 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1363 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1385 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2097 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1396 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7009 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6308 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6319 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5607 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5618 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5629 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_580 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_591 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4928 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4906 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4917 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4939 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6831 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6820 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6864 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6853 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6842 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6886 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6875 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6897 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1160 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1171 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1193 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1182 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6105 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6116 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5415 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5404 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6149 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6127 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6138 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5437 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5426 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5448 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4703 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5459 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4714 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4736 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4725 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4758 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4747 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4769 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_208 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_219 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6650 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6661 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6672 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6683 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6694 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5971 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5960 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5982 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5993 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3309 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2608 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2619 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1907 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1918 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1929 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5223 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5212 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5201 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5234 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4511 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5245 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5256 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4500 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3810 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4522 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4533 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4544 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5278 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5289 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5267 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4555 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3843 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3832 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3821 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4588 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4577 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4566 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3865 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3876 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3854 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4599 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3887 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3898 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6480 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6491 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5790 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3106 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3139 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3128 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3117 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2427 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2416 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2405 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2449 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2438 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1704 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1726 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1715 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1737 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1759 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1748 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_409 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5020 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5031 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5064 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4330 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5053 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5042 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4363 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4352 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4341 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5086 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5097 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5075 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4396 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4374 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4385 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3651 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3640 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2950 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3673 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3695 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3684 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3662 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2961 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2983 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2972 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2994 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_943 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_910 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_932 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_921 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_965 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_954 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_976 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_987 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_998 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_391 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_380 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2202 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2213 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2224 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1501 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2235 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2257 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2279 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2246 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2268 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1512 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1534 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1523 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1545 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1567 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1556 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1578 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1589 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_228 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_217 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_206 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_239 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4160 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4171 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3470 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4193 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4182 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3481 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3492 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2780 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2791 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_751 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_740 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_762 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_784 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_773 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_795 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2010 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2032 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2043 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2054 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2021 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1320 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1331 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1342 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2065 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2076 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2087 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1364 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1353 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1375 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2098 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1397 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1386 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6309 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5619 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5608 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_592 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_581 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_570 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4929 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4918 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4907 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6810 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6821 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6854 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6832 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6843 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6887 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6876 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6898 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6865 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1150 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1161 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1183 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1172 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1194 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6106 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6117 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5405 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6128 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6139 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5438 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5427 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5416 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5449 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4704 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4737 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4726 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4715 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4748 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4759 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_209 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6662 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6651 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6640 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6673 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6695 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5961 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5950 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6684 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5994 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5972 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5983 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_90 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2609 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1908 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1919 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5213 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5202 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5246 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5224 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5235 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4512 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5257 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4501 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3800 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4523 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4545 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4534 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5279 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5268 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3844 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3811 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3833 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3822 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4567 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4556 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4578 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3855 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3866 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3877 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4589 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3888 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3899 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6470 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6481 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6492 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5791 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5780 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3129 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3107 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3118 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2417 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2428 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2406 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2439 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1705 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1716 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1738 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1727 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1749 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5021 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5010 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5032 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5065 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4320 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5054 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5043 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4353 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4342 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4331 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5087 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5098 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5076 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4397 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4364 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4375 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4386 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3652 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3630 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3641 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2940 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3674 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3685 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3663 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2962 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2973 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2984 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2951 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3696 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2995 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_900 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_933 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_911 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_922 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_944 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_955 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_966 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_977 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_988 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_999 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_370 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_381 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_392 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2203 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2214 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2225 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2236 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2258 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2247 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2269 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1502 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1524 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1513 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1546 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1535 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1557 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1568 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1579 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_229 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_218 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_207 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4150 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4161 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4172 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3460 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4194 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4183 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3471 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3493 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3482 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2781 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2770 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2792 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_741 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_730 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_763 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_752 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_785 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_774 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_796 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2000 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2011 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2033 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2044 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2022 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1310 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1332 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1321 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1343 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2066 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2077 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2055 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1365 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1354 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1376 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2099 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2088 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1387 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1398 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3290 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5609 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_582 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_593 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_571 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_560 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4919 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4908 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6811 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6800 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6822 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6855 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6833 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6844 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6888 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6877 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6866 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6899 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1151 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1140 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1162 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1184 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1173 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1195 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6107 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5406 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6129 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6118 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5439 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5428 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5417 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_390 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4705 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4727 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4716 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4749 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4738 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6630 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6652 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6641 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6663 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6696 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6674 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6685 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5940 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5951 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5962 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5995 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5984 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5973 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_80 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_91 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1909 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5214 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5203 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5247 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4502 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5225 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5236 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3801 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4535 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5258 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4524 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4513 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5269 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4546 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3812 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3823 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3834 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4568 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4579 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4557 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3867 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3856 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3845 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3889 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3878 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6471 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6460 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5770 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6482 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6493 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5781 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5792 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_530 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3108 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3119 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2418 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2407 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2429 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1706 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1717 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1728 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1739 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5000 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5022 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5011 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4310 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4321 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5033 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5055 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5044 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5066 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4354 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4343 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4332 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5099 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5088 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5077 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4365 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4376 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4387 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3631 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3620 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3642 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2930 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4398 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2941 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3664 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3686 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3675 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3653 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2963 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2974 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2952 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3697 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2996 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2985 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_934 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_912 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_901 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_923 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_956 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_967 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_945 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_978 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_989 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6290 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_360 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_371 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_382 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_393 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2204 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2215 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2226 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2259 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2248 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2237 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1525 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1514 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1503 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1547 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1536 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1558 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1569 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_208 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_219 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4151 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4140 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4162 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3461 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3450 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4173 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4184 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4195 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3472 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3494 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3483 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2782 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2760 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2771 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2793 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_731 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_720 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_742 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_753 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_764 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_775 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_786 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_797 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_190 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2001 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1300 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2045 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2034 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2023 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2012 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1322 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1311 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1333 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2067 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2056 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2078 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1366 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1355 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1344 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2089 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1399 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1377 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1388 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3291 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3280 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2590 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_550 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4909 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_583 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_561 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_572 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_594 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6812 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6801 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6834 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6845 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6823 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6889 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6878 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6867 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6856 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1141 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1130 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1152 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1174 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1163 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1185 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1196 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6108 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6119 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5407 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5429 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5418 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_380 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_391 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4728 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4706 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4717 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4739 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6620 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6653 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6631 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6642 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6664 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6675 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6697 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6686 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5941 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5952 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5930 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5985 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5974 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5963 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5996 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_70 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_81 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_92 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5204 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5248 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5226 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4503 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5237 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5215 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4536 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5259 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4525 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4514 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3835 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3813 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3824 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3802 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4547 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4558 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4569 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3868 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3857 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3846 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3879 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6461 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6450 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6472 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5760 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6483 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6494 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5771 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5782 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5793 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_531 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_520 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3109 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2408 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2419 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1707 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1718 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1729 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5001 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5012 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5023 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4300 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4311 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5045 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5056 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5034 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5067 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4344 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4333 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3610 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4322 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5089 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5078 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4355 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4377 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4366 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3632 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3643 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3621 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4388 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4399 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2920 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2931 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3665 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3676 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3654 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2964 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2975 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2942 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2953 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3698 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3687 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2997 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2986 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_902 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_913 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_924 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_946 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_935 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_957 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6280 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_968 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_979 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6291 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5590 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_350 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_361 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_383 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_372 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_394 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2216 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2205 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2227 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2249 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2238 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1515 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1504 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1548 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1537 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1526 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1559 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_209 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4152 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4141 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4130 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4163 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3451 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3440 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4185 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4174 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4196 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3462 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3473 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3484 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2750 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2783 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2761 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2772 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3495 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2794 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_721 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_732 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_710 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_754 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_765 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_743 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_776 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_787 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_798 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_191 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_180 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2002 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2024 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2013 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2035 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1301 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1312 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1323 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1334 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2057 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2068 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2046 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1367 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1356 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1345 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2079 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1378 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1389 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3292 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3270 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3281 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2580 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2591 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1890 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_540 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_584 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_573 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_562 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_551 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_595 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6813 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6802 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6835 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6846 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6824 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6879 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6868 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6857 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1120 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1142 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1131 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1153 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1164 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1175 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1186 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1197 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6109 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5408 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5419 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_381 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_392 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_370 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4707 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4718 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4729 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6621 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6610 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6654 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6643 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6632 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6665 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6676 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6687 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5942 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5953 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5931 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5920 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5986 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6698 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5975 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5964 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5997 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_60 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_71 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_82 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_93 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5205 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5238 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5227 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5216 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4504 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4515 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5249 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4526 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4537 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3825 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3803 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3814 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4548 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4559 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3858 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3847 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3836 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3869 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7130 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6462 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6440 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6451 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5750 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5761 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6495 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6484 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6473 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5772 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5783 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5794 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_510 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_532 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_521 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2409 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1708 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1719 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5002 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5013 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4312 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4301 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5046 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5035 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5024 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4345 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3600 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4334 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4323 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5079 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5057 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5068 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4367 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4356 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4378 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3622 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3633 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3611 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2921 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2932 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2910 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3677 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3666 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3655 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4389 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3644 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2965 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2943 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2954 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3688 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3699 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2998 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2976 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2987 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_925 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_903 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_914 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_936 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_947 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_958 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_969 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6270 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6292 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6281 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5591 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5580 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4890 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_340 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_351 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_384 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_395 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_362 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_373 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2217 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2206 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2239 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1505 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2228 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1516 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1549 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1538 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1527 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4120 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4153 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4131 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4142 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3452 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3441 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3430 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4175 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4164 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4186 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2740 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3463 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3474 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3485 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4197 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2762 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2773 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2751 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3496 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2795 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2784 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_733 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_722 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_711 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_700 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_755 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_766 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_744 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_788 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_799 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_777 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_170 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_181 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_192 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2025 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2036 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2003 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2014 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1324 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1313 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1302 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2058 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2069 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2047 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1357 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1335 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1346 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1368 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1379 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3260 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3293 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3271 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3282 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2570 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2581 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2592 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1880 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1891 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_541 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_530 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_574 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_552 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_563 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_596 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_585 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6803 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6814 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6825 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6836 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6869 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6847 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6858 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1121 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1132 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1110 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1143 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1154 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1176 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1165 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1198 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1187 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3090 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5409 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_371 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_382 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_360 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4708 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4719 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_393 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6611 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6600 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6655 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6644 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6622 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6633 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5910 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6666 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6677 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5932 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5921 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5943 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6688 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6699 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5965 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5976 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5954 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5987 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5998 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_50 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_61 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_83 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_72 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_94 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5239 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5228 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5217 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5206 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_190 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4516 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4527 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4505 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3815 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3826 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3804 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4538 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4549 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3859 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3848 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3837 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7131 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7120 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6441 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6463 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6452 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6430 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5751 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5740 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6496 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6485 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6474 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5773 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5762 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5784 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5795 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_500 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_533 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_511 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_522 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_1709 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5003 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5014 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4302 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5047 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5036 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5025 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3601 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4324 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4335 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4313 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5058 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5069 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4357 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4379 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4346 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4368 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3623 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3634 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3612 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2922 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2911 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2900 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3667 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3656 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3645 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2966 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2933 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2944 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2955 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3689 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3678 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2988 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2999 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2977 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_915 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_904 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_937 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_948 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_926 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_959 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6260 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6271 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6282 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6293 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5570 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5592 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5581 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4880 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4891 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_341 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_330 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_352 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_385 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_374 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_363 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_396 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2218 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2207 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1506 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2229 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1539 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1528 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1517 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4110 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4154 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4121 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4132 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4143 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3442 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3431 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3420 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4165 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4176 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4187 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2730 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3464 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3475 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3453 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4198 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2752 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2763 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2774 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2741 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3486 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3497 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2796 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2785 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_712 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_723 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_701 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_734 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_756 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_745 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_767 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_778 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_789 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6090 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_160 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_182 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_171 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_193 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2026 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2015 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2004 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1314 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1303 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1325 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2059 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2048 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2037 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1358 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1336 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1347 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1369 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3250 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3294 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3272 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3261 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_8 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3283 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2571 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2560 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2582 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2593 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1870 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1892 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1881 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_520 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_531 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_575 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_553 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_564 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_542 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_586 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_597 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6804 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6815 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6826 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6837 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6859 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6848 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1100 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1111 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1122 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1133 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1155 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1144 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1166 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1177 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1199 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1188 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3080 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3091 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2390 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_350 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_372 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_383 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_361 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4709 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_394 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6612 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6601 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6634 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6645 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6623 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5900 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6656 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6667 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6678 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5911 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5933 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5922 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5944 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5955 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5966 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5977 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6689 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5999 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5988 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_51 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_62 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_40 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_73 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_95 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_84 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5229 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5218 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5207 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_180 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_191 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4517 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4528 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4506 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3816 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3805 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4539 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3838 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3849 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3827 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7121 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7110 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6420 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6453 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6431 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6442 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6464 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5752 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5741 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5730 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6497 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6475 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6486 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5763 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5774 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5785 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5796 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_501 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_523 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_534 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_512 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_5004 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5026 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5015 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4303 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5037 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4336 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4314 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4325 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5048 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5059 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4358 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4347 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4369 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3602 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3624 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3613 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2912 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2923 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2901 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3668 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3657 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3635 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3646 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2934 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2956 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2945 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3679 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2989 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2967 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2978 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_916 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_905 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_927 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_949 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_938 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6250 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6261 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5560 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6294 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6283 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6272 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5571 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5593 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5582 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4870 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4892 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4881 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_331 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_320 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_342 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_386 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_375 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_364 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_353 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_397 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2208 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2219 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1507 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1529 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1518 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4100 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4111 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4122 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4144 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4133 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3432 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3410 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3421 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4155 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4166 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4177 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2720 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2731 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3454 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3465 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3443 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3476 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4199 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4188 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2742 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2764 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2753 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3487 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3498 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2797 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2775 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2786 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_713 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_724 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_702 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_746 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_757 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_735 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6080 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_779 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_768 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6091 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5390 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_161 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_150 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_183 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_172 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_194 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2016 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2027 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2005 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1315 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1304 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2038 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2049 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1326 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1337 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1348 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1359 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3251 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3240 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3273 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3262 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_9 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3284 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2550 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2561 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2572 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3295 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2594 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2583 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1860 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1871 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1882 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1893 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_521 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_532 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_510 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_565 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_554 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_543 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_587 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_576 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_598 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6816 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6805 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6827 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6849 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6838 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1101 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1123 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1112 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1156 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1145 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1134 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1167 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1178 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1189 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3092 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3081 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3070 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2391 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2380 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1690 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_340 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_373 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_362 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_351 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_384 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_395 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6602 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6613 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6635 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6646 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6624 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5901 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6657 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6668 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6679 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5912 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5934 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5923 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5967 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5945 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5956 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5978 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5989 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_41 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_52 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_30 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_74 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_63 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_96 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_85 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5219 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5208 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_192 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_181 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_170 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4518 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4507 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3806 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3817 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4529 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3839 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3828 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7122 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7111 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7100 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6410 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6454 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6432 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6443 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6421 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5720 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6465 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5731 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5742 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6487 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6476 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5775 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5764 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5753 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6498 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5786 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5797 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_502 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_524 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_535 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_513 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_5005 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5027 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5016 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5038 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4304 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4326 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4315 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5049 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4359 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4348 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3603 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4337 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3614 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3625 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2913 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2902 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3658 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3647 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3636 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2935 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2957 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2946 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2924 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3669 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2968 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2979 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_906 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_917 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_928 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_939 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6251 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6240 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6262 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5550 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6284 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6295 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6273 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5561 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5572 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5594 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5583 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4871 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4860 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4882 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_310 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4893 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_321 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_332 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_343 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_354 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_365 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_376 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_387 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_398 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2209 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1519 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1508 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4101 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3400 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4134 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4145 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4123 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4112 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3433 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3411 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3422 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4156 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4167 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4178 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2710 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2721 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3466 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3444 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3455 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4189 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2743 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2765 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2754 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2732 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3477 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3488 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3499 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2787 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2798 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2776 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_714 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_703 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_758 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_747 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_725 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_736 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6070 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_769 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6081 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6092 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5391 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5380 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4690 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_140 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_151 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_184 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_173 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_162 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_195 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2006 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2017 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1305 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1316 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2039 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2028 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1327 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1338 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1349 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3230 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3241 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3252 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3274 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3263 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2540 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3285 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2551 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2562 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2573 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3296 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2584 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2595 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1861 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1850 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1894 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1872 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1883 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_500 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_522 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_511 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_533 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_544 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_555 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_566 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_577 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_599 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_588 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6806 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6817 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6828 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6839 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1102 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1124 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1113 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1146 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1135 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1157 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1168 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1179 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3093 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3082 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3071 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3060 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2370 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2381 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2392 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1680 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1691 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_341 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_330 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_374 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_363 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_352 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_396 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_385 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6603 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6636 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6614 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6625 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6647 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6658 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6669 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5902 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5913 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5924 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5935 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5968 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5957 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5946 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5979 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_42 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_53 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_31 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_20 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_75 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_64 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_86 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_97 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5209 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_182 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_171 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_160 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4519 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4508 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_193 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3807 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3829 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3818 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7123 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7112 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7101 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6411 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6400 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6422 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6444 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6433 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5710 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5721 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6466 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6455 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5732 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5743 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6488 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6477 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5776 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5754 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5765 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6499 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5787 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5798 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_503 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_514 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_525 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_536 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_5006 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5028 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5017 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4327 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4305 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4316 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5039 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4349 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3604 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4338 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3615 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2903 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2914 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3659 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3626 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3648 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3637 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2936 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2947 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2925 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2969 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2958 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_907 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_929 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_918 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6252 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6241 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6230 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5540 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5551 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6274 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6285 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6296 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6263 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5562 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5573 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5584 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4861 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4872 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4850 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4883 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5595 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_300 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4894 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_322 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_311 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_333 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_344 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_366 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_355 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_377 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_388 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_399 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_1509 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4102 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4135 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4113 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4124 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3423 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3412 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3401 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4157 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4146 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4168 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2700 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2711 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2722 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3445 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3467 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3456 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3434 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4179 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2744 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2755 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2733 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3478 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3489 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2788 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2766 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2777 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2799 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_715 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_704 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_737 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_748 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_726 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6071 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6060 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_759 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6093 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6082 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5392 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5381 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5370 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4680 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4691 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_141 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_130 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_152 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3990 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_185 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_163 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_174 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_196 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2018 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2007 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1306 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2029 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1317 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1328 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1339 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3242 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3231 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3220 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3253 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2530 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3275 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3264 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3286 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2563 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2552 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2541 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3297 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2596 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2574 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2585 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1840 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1851 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1862 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1884 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1873 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1895 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_501 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_523 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_512 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_534 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_556 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_545 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_578 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_589 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_567 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6807 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6818 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6829 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1103 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1114 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1125 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1147 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1158 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1136 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1169 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3050 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3083 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3072 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3061 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2360 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2371 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2382 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3094 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2393 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1670 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1692 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1681 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_331 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_320 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_342 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_353 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_364 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_397 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_386 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_375 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6626 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6637 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6615 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6604 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6659 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6648 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5914 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5903 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5925 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5936 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5947 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5958 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5969 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_10 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_43 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_21 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_32 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_76 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_65 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_87 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_54 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_98 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2190 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_172 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_150 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_161 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_183 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4509 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_194 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3808 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3819 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7113 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7102 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7124 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6401 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5700 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6423 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6445 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6434 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6412 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5711 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5722 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6467 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5733 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6456 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6478 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5755 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5766 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5777 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5744 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6489 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5788 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5799 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_504 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_526 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_515 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_537 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6990 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5007 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5029 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5018 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4317 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4306 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3605 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4339 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4328 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3616 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2904 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3638 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3649 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3627 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2915 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2937 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2926 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2948 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2959 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6220 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_908 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_919 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6231 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6253 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6242 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5530 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5541 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6275 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6286 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6264 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4840 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5563 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5574 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5552 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5585 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6297 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4862 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4851 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4873 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5596 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CONV2TO1_301 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4884 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4895 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_323 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_334 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_312 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_345 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_356 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_367 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_389 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_378 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4103 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4136 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4125 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4114 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3424 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3413 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3402 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4147 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4158 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4169 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2701 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2712 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3457 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3446 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3435 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2745 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2756 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2734 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2723 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3479 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3468 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2789 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2767 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2778 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_705 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_749 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_738 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_716 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_727 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6050 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6061 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6083 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6072 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6094 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5360 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5393 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5382 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5371 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4670 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4681 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3980 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4692 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_142 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_131 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_120 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3991 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_164 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_175 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_153 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_186 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_197 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2008 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1307 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2019 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1318 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1329 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3232 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3210 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3221 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3243 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3254 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2531 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2520 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3265 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3276 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3287 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2553 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2564 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2542 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3298 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2597 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2575 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2586 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1830 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1852 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1841 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1885 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1863 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1896 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1874 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_513 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_502 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_546 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_557 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_524 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_535 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_579 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_568 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5190 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6819 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6808 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1104 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1115 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1148 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1137 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1126 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1159 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3040 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3062 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3051 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3084 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3073 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3095 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2350 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2361 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2372 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2394 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2383 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1671 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1660 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1693 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1682 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_332 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_310 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_321 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_365 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_343 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_354 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_376 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_387 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_398 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6616 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6627 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6605 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6638 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6649 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5915 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5904 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5926 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5959 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5948 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5937 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_44 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_33 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_22 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_11 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_77 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_55 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_66 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_88 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_99 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2180 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2191 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1490 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_140 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_162 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_173 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_151 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_195 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_184 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3809 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7114 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7103 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_7125 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6402 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6424 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6435 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6413 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5712 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5701 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5723 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6468 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5734 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6457 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6446 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6479 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5767 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5745 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5756 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5778 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5789 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_505 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_516 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_527 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_6980 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6991 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5008 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5019 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4307 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4318 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3606 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4329 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2905 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3628 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3617 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3639 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2916 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2927 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2938 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2949 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6210 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_909 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6221 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6232 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6243 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5542 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5531 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6276 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6287 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6254 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6265 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5520 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5564 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4830 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5575 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5553 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6298 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4852 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4863 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5586 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4841 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4874 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5597 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4885 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4896 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_324 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_302 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_313 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_346 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_335 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_368 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_357 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_379 DCDC_MUX_9/m1_336_3180# DCDC_CAP_UNIT_5/c1_100_100# VPWR VGND VOUT
+ DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_5/m3_72_0# clk1b
+ clk0b DCDC_MUX_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_4104 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4126 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4115 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3414 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3403 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4159 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4148 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4137 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2702 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2713 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3447 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3458 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3436 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3425 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2735 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2746 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2724 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3469 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2779 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2757 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2768 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_706 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_739 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_728 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_717 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6062 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6040 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6051 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6084 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6073 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6095 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5350 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5372 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5383 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5361 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5394 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4671 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4660 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4682 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3970 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4693 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CONV2TO1_110 DCDC_MUX_3/m1_336_3180# DCDC_CONV2TO1_88/m1_1082_1484# VPWR VGND
+ DCDC_MUX_5/m2_2834_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT_7121/m3_72_0#
+ DCDC_CAP_UNIT_7125/m3_72_0# clk1b clk0b DCDC_MUX_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_143 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_121 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_132 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_3981 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3992 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CONV2TO1_165 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_176 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_154 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_187 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CONV2TO1_198 DCDC_MUX_7/m1_336_3180# DCDC_CAP_UNIT_7101/c1_100_100# VPWR VGND
+ DCDC_MUX_9/m2_2834_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT_7085/m3_72_0#
+ DCDC_CAP_UNIT_7101/m3_72_0# clk1b clk0b DCDC_MUX_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1
XDCDC_CAP_UNIT_2009 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1308 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1319 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_MUX_0 SEL_L[0] DCDC_MUX_0/m1_336_3180# DCDC_MUX_0/m1_2572_3264# VPWR SEL_H[0]
+ VGND VGND DCDC_MUX
XDCDC_CAP_UNIT_3233 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3200 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3222 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3211 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2521 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3244 DCDC_CAP_UNIT_7109/m3_72_0# DCDC_CONV2TO1_9/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3255 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2510 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3266 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2532 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3288 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3277 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2554 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2543 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3299 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1820 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2598 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2565 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2576 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2587 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1831 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1842 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1853 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1886 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1875 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1864 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1897 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_514 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_503 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_525 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_536 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_547 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_569 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_558 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5191 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_5180 DCDC_CAP_UNIT_7117/m3_72_0# DCDC_CONV2TO1_9/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_4490 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_6809 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1105 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1149 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1138 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1116 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1127 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3030 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3041 DCDC_CAP_UNIT_7131/m3_72_0# DCDC_CONV2TO1_66/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3063 DCDC_CAP_UNIT_7130/m3_72_0# DCDC_CONV2TO1_66/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3052 DCDC_CAP_UNIT_7129/m3_72_0# DCDC_CONV2TO1_84/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3074 DCDC_CAP_UNIT_7121/m3_72_0# DCDC_CONV2TO1_88/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3096 DCDC_CAP_UNIT_7127/m3_72_0# DCDC_CONV2TO1_84/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2373 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2351 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2362 DCDC_CAP_UNIT_7101/m3_72_0# DCDC_CAP_UNIT_7101/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2340 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_3085 DCDC_CAP_UNIT_7125/m3_72_0# DCDC_CONV2TO1_88/m1_1082_1484# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2395 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_2384 DCDC_CAP_UNIT_7085/m3_72_0# DCDC_CONV2TO1_537/m1_738_1568# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1650 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1661 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1683 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1672 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_1694 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_322 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_300 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_311 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_344 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_333 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_355 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_377 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_388 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_366 DCDC_CAP_UNIT_5/m3_72_0# DCDC_CAP_UNIT_5/c1_100_100# DCDC_CAP_UNIT
XDCDC_CAP_UNIT_399 DCDC_CAP_UNIT_9/m3_72_0# DCDC_CAP_UNIT_9/c1_100_100# DCDC_CAP_UNIT
.ends

.subckt CMC_PMOS_23131506_X1_Y1_1653158394 a_402_525# a_200_252# w_0_0# a_230_525#
X0 w_0_0# a_200_252# a_402_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X2 w_0_0# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_402_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt CCP_S_NMOS_B_5782581_X1_Y1_1653158393 a_147_525# a_835_525# a_200_252# a_241_1232#
+ a_230_525#
X0 a_200_252# a_230_525# a_835_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_835_525# a_230_525# a_200_252# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X3 a_147_525# a_200_252# a_230_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DP_NMOS_B_93310865_X1_Y1_1653158395 a_402_525# a_372_252# a_147_525# a_200_252#
+ a_241_1232# a_230_525#
X0 a_402_525# a_372_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=3.402e+11p ps=4.14e+06u w=420000u l=150000u
X1 a_147_525# a_372_252# a_402_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X3 a_147_525# a_200_252# a_230_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt CCP_PMOS_58853955_X1_Y1_1653158392 a_200_252# w_0_0# a_230_525#
X0 w_0_0# a_230_525# a_200_252# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X2 w_0_0# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_200_252# a_230_525# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NMOS_S_93862694_X1_Y1_1653158396 a_200_252# a_230_483# a_147_483#
X0 a_230_483# a_200_252# a_147_483# a_147_483# sky130_fd_pr__nfet_01v8 ad=2.352e+11p pd=2.24e+06u as=4.452e+11p ps=4.42e+06u w=840000u l=150000u
X1 a_147_483# a_200_252# a_230_483# a_147_483# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
.ends

.subckt DCDC_COMP VIN VIP VGND CLK VOP VPWR
XCMC_PMOS_23131506_X1_Y1_1653158394_0 m1_1311_2036# CLK VPWR VOP CMC_PMOS_23131506_X1_Y1_1653158394
XCMC_PMOS_23131506_X1_Y1_1653158394_1 m1_2343_2456# CLK VPWR m1_1655_2540# CMC_PMOS_23131506_X1_Y1_1653158394
XCCP_S_NMOS_B_5782581_X1_Y1_1653158393_0 m1_2343_2456# m1_1655_2540# m1_1311_2036#
+ VGND VOP CCP_S_NMOS_B_5782581_X1_Y1_1653158393
XDP_NMOS_B_93310865_X1_Y1_1653158395_0 m1_1655_2540# VIP li_2318_3811# VIN VGND m1_2343_2456#
+ DP_NMOS_B_93310865_X1_Y1_1653158395
XCCP_PMOS_58853955_X1_Y1_1653158392_0 m1_1311_2036# VPWR VOP CCP_PMOS_58853955_X1_Y1_1653158392
XNMOS_S_93862694_X1_Y1_1653158396_0 CLK li_2318_3811# VGND NMOS_S_93862694_X1_Y1_1653158396
.ends

.subckt top_level clk config_in[0] config_in[1] config_in[2] config_in[3] config_in[4]
+ config_in[5] noise_D[3] noise_D[2] noise_D[1] noise_D[0] DAC_RST VREF_out D[1] D[3]
+ D[4] D[2] D[0] D[5] VOUT clk_noise non_clk_rst_n non_clk_control VPWR VREF_in Noise_in
+ VGND
XNON_CLK_GEN_0 clk_noise DCDC_FF_0/D NON_CLK_GEN_0/clk0 NON_CLK_GEN_0/clk0b NON_CLK_GEN_0/clk1
+ NON_CLK_GEN_0/clk1b non_clk_control non_clk_rst_n VPWR VGND NON_CLK_GEN
XDCDC_CLKGATE_0 VGND VPWR clk DCDC_FF_0/CLK DCDC_COMP_0/VOP DCDC_CLKGATE
XNOISE_INJECTION_0 noise_D[3] noise_D[0] noise_D[1] noise_D[2] VREF_in Noise_in VGND
+ NOISE_INJECTION
Xdcdc_config_0 VPWR config_in[0] config_in[1] config_in[2] config_in[3] config_in[4]
+ config_in[5] dcdc_config_0/s[0] dcdc_config_0/s[10] dcdc_config_0/s[11] dcdc_config_0/s[1]
+ dcdc_config_0/s[2] dcdc_config_0/s[3] dcdc_config_0/s[4] dcdc_config_0/s[5] dcdc_config_0/s[6]
+ dcdc_config_0/s[7] dcdc_config_0/s[8] dcdc_config_0/s[9] VGND dcdc_config
XDCDC_INVERTER_0 VGND VPWR DCDC_FF_0/Q DCDC_FF_0/D DCDC_INVERTER
XDCDC_DAC_0 DAC_RST VREF_out D[1] D[4] D[3] D[5] D[2] D[0] DCDC_DAC_0/VPWR VPWR VGND
+ DCDC_DAC
XDCDC_FF_0 VGND VPWR DCDC_FF_0/D DCDC_FF_0/CLK DCDC_FF_0/Q DCDC_FF
Xsix_stage_conv_0 NON_CLK_GEN_0/clk0b NON_CLK_GEN_0/clk1b NON_CLK_GEN_0/clk1 NON_CLK_GEN_0/clk0
+ dcdc_config_0/s[0] dcdc_config_0/s[1] dcdc_config_0/s[2] dcdc_config_0/s[3] dcdc_config_0/s[4]
+ dcdc_config_0/s[5] dcdc_config_0/s[6] dcdc_config_0/s[7] dcdc_config_0/s[8] dcdc_config_0/s[9]
+ dcdc_config_0/s[10] dcdc_config_0/s[11] VOUT VPWR VGND six_stage_conv
XDCDC_COMP_0 VOUT VREF_in VGND DCDC_COMP_0/CLK DCDC_COMP_0/VOP VPWR DCDC_COMP
.ends

.subckt PMU VSUBS
X2fF_decap_2[0] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_2[1] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_2[2] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_2[3] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_2[4] top_level_0/VPWR VSUBS x2fF_decap
Xtop_level_0 top_level_0/clk top_level_0/config_in[0] top_level_0/config_in[1] top_level_0/config_in[2]
+ top_level_0/config_in[3] top_level_0/config_in[4] top_level_0/config_in[5] top_level_0/noise_D[3]
+ top_level_0/noise_D[2] top_level_0/noise_D[1] top_level_0/noise_D[0] top_level_0/DAC_RST
+ top_level_0/VREF_out top_level_0/D[1] top_level_0/D[3] top_level_0/D[4] top_level_0/D[2]
+ top_level_0/D[0] top_level_0/D[5] top_level_0/VOUT top_level_0/clk_noise top_level_0/non_clk_rst_n
+ top_level_0/non_clk_control top_level_0/VPWR top_level_0/VREF_in top_level_0/Noise_in
+ VSUBS top_level
X2fF_decap_0[0] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_0[1] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_0[2] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_0[3] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_0[4] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_1[0] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_1[1] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_1[2] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_1[3] top_level_0/VPWR VSUBS x2fF_decap
X2fF_decap_1[4] top_level_0/VPWR VSUBS x2fF_decap
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1 a_n358_n50# a_n300_n147# w_n558_n347# a_300_n50#
X0 a_300_n50# a_n300_n147# a_n358_n50# w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_pmos sky130_fd_pr__pfet_g5v0d10v5$1_0/a_300_n50# sky130_fd_pr__pfet_g5v0d10v5$1_0/a_n358_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1_0/a_n300_n147# sky130_fd_pr__pfet_g5v0d10v5$1_0/w_n558_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$1_0 sky130_fd_pr__pfet_g5v0d10v5$1_0/a_n358_n50# sky130_fd_pr__pfet_g5v0d10v5$1_0/a_n300_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1_0/w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5$1_0/a_300_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1
.ends

.subckt x1T1R_w50_l300_pmos B D DIODE
Xw50_l300_pmos_0 D RRAM$7_0/TE w_5419_n25463# li_n19119_n22791# w50_l300_pmos
D0 RRAM$7_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$5 a_n492_n272# a_n358_n50# a_300_n50# a_n300_n138#
X0 a_300_n50# a_n300_n138# a_n358_n50# a_n492_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$5_0/a_n358_n50# sky130_fd_pr__nfet_g5v0d10v5$5_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$5_0/a_300_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$5_0 VSUBS sky130_fd_pr__nfet_g5v0d10v5$5_0/a_n358_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$5_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$5_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$5
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$4 a_n358_n50# a_n300_n147# w_n558_n347# a_300_n50#
X0 a_300_n50# a_n300_n147# a_n358_n50# w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$4_0/a_n300_n147# sky130_fd_pr__pfet_g5v0d10v5$4_0/a_n358_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$4_0/w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5$4_0/a_300_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$4_0 sky130_fd_pr__pfet_g5v0d10v5$4_0/a_n358_n50# sky130_fd_pr__pfet_g5v0d10v5$4_0/a_n300_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$4_0/w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5$4_0/a_300_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$4
.ends

.subckt x2T1R_w50_l300 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$2_0/VSUBS
Xw50_l300_nmos$1_0 m1_n18719_n22101# w_5419_n25463# RRAM$4$2_0/TE RRAM$4$2_0/VSUBS
+ w50_l300_nmos$1
Xw50_l300_pmos$1_0 w_41419_n25463# RRAM$4$2_0/TE li_n19119_n20775# m1_n18719_n22101#
+ w50_l300_pmos$1
D0 RRAM$4$2_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$2_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$2 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos sky130_fd_pr__nfet_g5v0d10v5$2_0/a_500_n50# sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n558_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$2_0 sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n500_n138# sky130_fd_pr__nfet_g5v0d10v5$2_0/a_500_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n558_n50# sky130_fd_pr__nfet_g5v0d10v5$2
.ends

.subckt x1T1R_w50_l500_nmos B D DIODE RRAM$2_0/VSUBS
Xw50_l500_nmos_0 RRAM$2_0/TE w_5419_n25463# m1_n18719_n21695# RRAM$2_0/VSUBS w50_l500_nmos
D0 RRAM$2_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$3 a_1000_n50# w_n1258_n347# a_n1000_n147# a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$1$3_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_1000_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$3_0 sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$1$3
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$2 a_n1000_n138# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1058_n50#
+ VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$2_0 sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1000_n138#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5$1$2
.ends

.subckt x2T1R_w50_l1000 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$5_0/VSUBS
Xw50_l1000_pmos$1_0 li_n19119_n18569# w_41419_n25463# RRAM$4$5_0/TE m1_n18719_n20953#
+ w50_l1000_pmos$1
Xw50_l1000_nmos$1_0 w_5419_n25463# m1_n18719_n20953# RRAM$4$5_0/VSUBS w50_l1000_nmos$1
D0 RRAM$4$5_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$5_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n158_n50# sky130_fd_pr__nfet_g5v0d10v5$4_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n100_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4_0 sky130_fd_pr__nfet_g5v0d10v5$4_0/a_100_n50# sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n158_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$4
.ends

.subckt x1T1R_w50_l100_nmos B D DIODE RRAM$4_0/VSUBS
Xw50_l100_nmos_0 m1_n18719_n22101# RRAM$4_0/TE w_5419_n25463# RRAM$4_0/VSUBS w50_l100_nmos
D0 RRAM$4_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt x1T1R_NOMOS TOP_ELECTRODE
D0 RRAM$5_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$1 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_500_n50# sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n500_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$1_0 sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_500_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$2 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n500_n147# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_500_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n558_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$2_0 sky130_fd_pr__pfet_g5v0d10v5$1$2_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2
.ends

.subckt x2T1R_w50_l500 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$3_0/VSUBS
Xw50_l500_nmos$1_0 RRAM$4$3_0/TE m1_n18719_n21803# w_5419_n25463# RRAM$4$3_0/VSUBS
+ w50_l500_nmos$1
Xw50_l500_pmos$1_0 w_41419_n25463# m1_n18719_n21803# li_n19119_n20673# RRAM$4$3_0/TE
+ w50_l500_pmos$1
D0 RRAM$4$3_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$3_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$1 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_500_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n500_n147# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/w_n758_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$1$1_0 sky130_fd_pr__pfet_g5v0d10v5$1$1_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1
.ends

.subckt x1T1R_w50_l500_pmos B D DIODE
Xw50_l500_pmos_0 RRAM$8_0/TE D w_5419_n25463# li_n19119_n22791# w50_l500_pmos
D0 RRAM$8_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1 a_700_n50# a_n892_n272# a_n758_n50# a_n700_n138#
X0 a_700_n50# a_n700_n138# a_n758_n50# a_n892_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_nmos sky130_fd_pr__nfet_g5v0d10v5$1_0/a_n700_n138# sky130_fd_pr__nfet_g5v0d10v5$1_0/a_700_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$1_0/a_n758_n50#
Xsky130_fd_pr__nfet_g5v0d10v5$1_0 sky130_fd_pr__nfet_g5v0d10v5$1_0/a_700_n50# VSUBS
+ sky130_fd_pr__nfet_g5v0d10v5$1_0/a_n758_n50# sky130_fd_pr__nfet_g5v0d10v5$1_0/a_n700_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$1
.ends

.subckt x1T1R_w50_l700_nmos B D DIODE RRAM$1_0/VSUBS
Xw50_l700_nmos_0 w_5419_n25463# RRAM$1_0/TE RRAM$1_0/VSUBS m1_n18719_n21593# w50_l700_nmos
D0 RRAM$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5 a_n1000_n138# a_1000_n50# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos sky130_fd_pr__nfet_g5v0d10v5_0/a_1000_n50# sky130_fd_pr__nfet_g5v0d10v5_0/a_n1000_n138#
+ sky130_fd_pr__nfet_g5v0d10v5_0/a_n1058_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_0 sky130_fd_pr__nfet_g5v0d10v5_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5_0/a_1000_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5
.ends

.subckt x1T1R_w50_l1000_nmos B D DIODE RRAM_0/VSUBS
Xw50_l1000_nmos_0 RRAM_0/TE w_5419_n25463# m1_n18719_n21199# RRAM_0/VSUBS w50_l1000_nmos
D0 RRAM_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5 w_n358_n347# a_100_n50# a_n158_n50# a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos sky130_fd_pr__pfet_g5v0d10v5_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5_0/a_100_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_0/a_n158_n50#
Xsky130_fd_pr__pfet_g5v0d10v5_0 sky130_fd_pr__pfet_g5v0d10v5_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_0/a_100_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_0/a_n158_n50# sky130_fd_pr__pfet_g5v0d10v5_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5
.ends

.subckt x1T1R_w50_l100_pmos B D DIODE
Xw50_l100_pmos_0 w_5419_n25463# D li_n19119_n22791# RRAM$6_0/TE w50_l100_pmos
D0 RRAM$6_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4$1 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n158_n50# sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_100_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4$1_0 sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n100_n138# sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n158_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$4$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_AQFHUS w_n358_n347# a_100_n50# a_n158_n50# a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos$1 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n158_n50#
Xsky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/w_n358_n347#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n158_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS
.ends

.subckt x2T1R_w50_l100 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$1_0/VSUBS
Xw50_l100_nmos$1_0 m1_n18719_n22101# w_5419_n25463# RRAM$4$1_0/TE RRAM$4$1_0/VSUBS
+ w50_l100_nmos$1
Xw50_l100_pmos$1_0 m1_n18719_n22101# w_41419_n25463# li_n19119_n20775# RRAM$4$1_0/TE
+ w50_l100_pmos$1
D0 RRAM$4$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$3 a_n492_n272# a_n358_n50# a_300_n50# a_n300_n138#
X0 a_300_n50# a_n300_n138# a_n358_n50# a_n492_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_nmos sky130_fd_pr__nfet_g5v0d10v5$3_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$3_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$3_0/a_n358_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$3_0 VSUBS sky130_fd_pr__nfet_g5v0d10v5$3_0/a_n358_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$3_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$3_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$3
.ends

.subckt x1T1R_w50_l300_nmos B D DIODE RRAM$3_0/VSUBS
Xw50_l300_nmos_0 RRAM$3_0/TE w_5419_n25463# m1_n18719_n21895# RRAM$3_0/VSUBS w50_l300_nmos
D0 RRAM$3_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$5 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347#
X0 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$5_0/a_n758_n50# sky130_fd_pr__pfet_g5v0d10v5$5_0/a_n700_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$5_0/a_700_n50# sky130_fd_pr__pfet_g5v0d10v5$5_0/w_n958_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$5_0 sky130_fd_pr__pfet_g5v0d10v5$5_0/a_700_n50# sky130_fd_pr__pfet_g5v0d10v5$5_0/a_n700_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$5_0/a_n758_n50# sky130_fd_pr__pfet_g5v0d10v5$5_0/w_n958_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$5
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$6 a_700_n50# a_n892_n272# a_n758_n50# a_n700_n138#
X0 a_700_n50# a_n700_n138# a_n758_n50# a_n892_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$6_0/a_700_n50# sky130_fd_pr__nfet_g5v0d10v5$6_0/a_n758_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$6_0/a_n700_n138#
Xsky130_fd_pr__nfet_g5v0d10v5$6_0 sky130_fd_pr__nfet_g5v0d10v5$6_0/a_700_n50# VSUBS
+ sky130_fd_pr__nfet_g5v0d10v5$6_0/a_n758_n50# sky130_fd_pr__nfet_g5v0d10v5$6_0/a_n700_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$6
.ends

.subckt x2T1R_w50_l700 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$4_0/VSUBS
Xw50_l700_pmos$1_0 RRAM$4$4_0/TE w_41419_n25463# m1_n18719_n21684# li_n19119_n20024#
+ w50_l700_pmos$1
Xw50_l700_nmos$1_0 RRAM$4$4_0/TE m1_n18719_n21684# RRAM$4$4_0/VSUBS w_5419_n25463#
+ w50_l700_nmos$1
D0 RRAM$4$4_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$4_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$2 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347#
X0 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_pmos sky130_fd_pr__pfet_g5v0d10v5$2_0/a_700_n50# sky130_fd_pr__pfet_g5v0d10v5$2_0/a_n700_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$2_0/w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5$2_0/a_n758_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$2_0 sky130_fd_pr__pfet_g5v0d10v5$2_0/a_700_n50# sky130_fd_pr__pfet_g5v0d10v5$2_0/a_n700_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$2_0/a_n758_n50# sky130_fd_pr__pfet_g5v0d10v5$2_0/w_n958_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$2
.ends

.subckt x1T1R_w50_l700_pmos B D DIODE
Xw50_l700_pmos_0 D w_5419_n25463# li_n19119_n22791# RRAM$9_0/TE w50_l700_pmos
D0 RRAM$9_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$3 a_1000_n50# w_n1258_n347# a_n1000_n147# a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos sky130_fd_pr__pfet_g5v0d10v5$3_0/a_1000_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/w_n1258_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1000_n147#
Xsky130_fd_pr__pfet_g5v0d10v5$3_0 sky130_fd_pr__pfet_g5v0d10v5$3_0/a_1000_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/w_n1258_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1000_n147# sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1058_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$3
.ends

.subckt x1T1R_w50_l1000_pmos B D DIODE
Xw50_l1000_pmos_0 D li_n19119_n22791# RRAM$10_0/TE w_5419_n25463# w50_l1000_pmos
D0 RRAM$10_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt x1T1R_2T1R_nmos_pmos VSUBS
Xx1T1R_w50_l300_pmos_0[0] x1T1R_w50_l300_pmos_0[0]/B x1T1R_w50_l300_pmos_0[0]/D x1T1R_w50_l300_pmos_0[0]/DIODE
+ x1T1R_w50_l300_pmos
Xx1T1R_w50_l300_pmos_0[1] x1T1R_w50_l300_pmos_0[1]/B x1T1R_w50_l300_pmos_0[1]/D x1T1R_w50_l300_pmos_0[1]/DIODE
+ x1T1R_w50_l300_pmos
Xx1T1R_w50_l300_pmos_0[2] x1T1R_w50_l300_pmos_0[2]/B x1T1R_w50_l300_pmos_0[2]/D x1T1R_w50_l300_pmos_0[2]/DIODE
+ x1T1R_w50_l300_pmos
Xx2T1R_w50_l300_0[0] x2T1R_w50_l300_0[0]/G_n x2T1R_w50_l300_0[0]/G_p x2T1R_w50_l300_0[0]/DIODE_p
+ x2T1R_w50_l300_0[0]/DIODE_n x2T1R_w50_l300_0[0]/B_n x2T1R_w50_l300_0[0]/B_p x2T1R_w50_l300_0[0]/D
+ VSUBS x2T1R_w50_l300
Xx2T1R_w50_l300_0[1] x2T1R_w50_l300_0[1]/G_n x2T1R_w50_l300_0[1]/G_p x2T1R_w50_l300_0[1]/DIODE_p
+ x2T1R_w50_l300_0[1]/DIODE_n x2T1R_w50_l300_0[1]/B_n x2T1R_w50_l300_0[1]/B_p x2T1R_w50_l300_0[1]/D
+ VSUBS x2T1R_w50_l300
Xx2T1R_w50_l300_0[2] x2T1R_w50_l300_0[2]/G_n x2T1R_w50_l300_0[2]/G_p x2T1R_w50_l300_0[2]/DIODE_p
+ x2T1R_w50_l300_0[2]/DIODE_n x2T1R_w50_l300_0[2]/B_n x2T1R_w50_l300_0[2]/B_p x2T1R_w50_l300_0[2]/D
+ VSUBS x2T1R_w50_l300
Xx1T1R_w50_l500_nmos_0[0] x1T1R_w50_l500_nmos_0[0]/B x1T1R_w50_l500_nmos_0[0]/D x1T1R_w50_l500_nmos_0[0]/DIODE
+ VSUBS x1T1R_w50_l500_nmos
Xx1T1R_w50_l500_nmos_0[1] x1T1R_w50_l500_nmos_0[1]/B x1T1R_w50_l500_nmos_0[1]/D x1T1R_w50_l500_nmos_0[1]/DIODE
+ VSUBS x1T1R_w50_l500_nmos
Xx1T1R_w50_l500_nmos_0[2] x1T1R_w50_l500_nmos_0[2]/B x1T1R_w50_l500_nmos_0[2]/D x1T1R_w50_l500_nmos_0[2]/DIODE
+ VSUBS x1T1R_w50_l500_nmos
Xx1T1R_w50_l500_nmos_0[3] x1T1R_w50_l500_nmos_0[3]/B x1T1R_w50_l500_nmos_0[3]/D x1T1R_w50_l500_nmos_0[3]/DIODE
+ VSUBS x1T1R_w50_l500_nmos
Xx2T1R_w50_l300_1[0] x2T1R_w50_l300_1[0]/G_n x2T1R_w50_l300_1[0]/G_p x2T1R_w50_l300_1[0]/DIODE_p
+ x2T1R_w50_l300_1[0]/DIODE_n x2T1R_w50_l300_1[0]/B_n x2T1R_w50_l300_1[0]/B_p x2T1R_w50_l300_1[0]/D
+ VSUBS x2T1R_w50_l300
Xx2T1R_w50_l300_1[1] x2T1R_w50_l300_1[1]/G_n x2T1R_w50_l300_1[1]/G_p x2T1R_w50_l300_1[1]/DIODE_p
+ x2T1R_w50_l300_1[1]/DIODE_n x2T1R_w50_l300_1[1]/B_n x2T1R_w50_l300_1[1]/B_p x2T1R_w50_l300_1[1]/D
+ VSUBS x2T1R_w50_l300
Xx2T1R_w50_l300_1[2] x2T1R_w50_l300_1[2]/G_n x2T1R_w50_l300_1[2]/G_p x2T1R_w50_l300_1[2]/DIODE_p
+ x2T1R_w50_l300_1[2]/DIODE_n x2T1R_w50_l300_1[2]/B_n x2T1R_w50_l300_1[2]/B_p x2T1R_w50_l300_1[2]/D
+ VSUBS x2T1R_w50_l300
Xx2T1R_w50_l1000_0[0] x2T1R_w50_l1000_0[0]/G_n x2T1R_w50_l1000_0[0]/G_p x2T1R_w50_l1000_0[0]/DIODE_p
+ x2T1R_w50_l1000_0[0]/DIODE_n x2T1R_w50_l1000_0[0]/B_n x2T1R_w50_l1000_0[0]/B_p x2T1R_w50_l1000_0[0]/D
+ VSUBS x2T1R_w50_l1000
Xx2T1R_w50_l1000_0[1] x2T1R_w50_l1000_0[1]/G_n x2T1R_w50_l1000_0[1]/G_p x2T1R_w50_l1000_0[1]/DIODE_p
+ x2T1R_w50_l1000_0[1]/DIODE_n x2T1R_w50_l1000_0[1]/B_n x2T1R_w50_l1000_0[1]/B_p x2T1R_w50_l1000_0[1]/D
+ VSUBS x2T1R_w50_l1000
Xx2T1R_w50_l1000_0[2] x2T1R_w50_l1000_0[2]/G_n x2T1R_w50_l1000_0[2]/G_p x2T1R_w50_l1000_0[2]/DIODE_p
+ x2T1R_w50_l1000_0[2]/DIODE_n x2T1R_w50_l1000_0[2]/B_n x2T1R_w50_l1000_0[2]/B_p x2T1R_w50_l1000_0[2]/D
+ VSUBS x2T1R_w50_l1000
Xx2T1R_w50_l1000_1[0] x2T1R_w50_l1000_1[0]/G_n x2T1R_w50_l1000_1[0]/G_p x2T1R_w50_l1000_1[0]/DIODE_p
+ x2T1R_w50_l1000_1[0]/DIODE_n x2T1R_w50_l1000_1[0]/B_n x2T1R_w50_l1000_1[0]/B_p x2T1R_w50_l1000_1[0]/D
+ VSUBS x2T1R_w50_l1000
Xx2T1R_w50_l1000_1[1] x2T1R_w50_l1000_1[1]/G_n x2T1R_w50_l1000_1[1]/G_p x2T1R_w50_l1000_1[1]/DIODE_p
+ x2T1R_w50_l1000_1[1]/DIODE_n x2T1R_w50_l1000_1[1]/B_n x2T1R_w50_l1000_1[1]/B_p x2T1R_w50_l1000_1[1]/D
+ VSUBS x2T1R_w50_l1000
Xx2T1R_w50_l1000_1[2] x2T1R_w50_l1000_1[2]/G_n x2T1R_w50_l1000_1[2]/G_p x2T1R_w50_l1000_1[2]/DIODE_p
+ x2T1R_w50_l1000_1[2]/DIODE_n x2T1R_w50_l1000_1[2]/B_n x2T1R_w50_l1000_1[2]/B_p x2T1R_w50_l1000_1[2]/D
+ VSUBS x2T1R_w50_l1000
Xx1T1R_w50_l100_nmos_0[0] x1T1R_w50_l100_nmos_0[0]/B x1T1R_w50_l100_nmos_0[0]/D x1T1R_w50_l100_nmos_0[0]/DIODE
+ VSUBS x1T1R_w50_l100_nmos
Xx1T1R_w50_l100_nmos_0[1] x1T1R_w50_l100_nmos_0[1]/B x1T1R_w50_l100_nmos_0[1]/D x1T1R_w50_l100_nmos_0[1]/DIODE
+ VSUBS x1T1R_w50_l100_nmos
Xx1T1R_w50_l100_nmos_0[2] x1T1R_w50_l100_nmos_0[2]/B x1T1R_w50_l100_nmos_0[2]/D x1T1R_w50_l100_nmos_0[2]/DIODE
+ VSUBS x1T1R_w50_l100_nmos
Xx1T1R_w50_l100_nmos_0[3] x1T1R_w50_l100_nmos_0[3]/B x1T1R_w50_l100_nmos_0[3]/D x1T1R_w50_l100_nmos_0[3]/DIODE
+ VSUBS x1T1R_w50_l100_nmos
Xx1T1R_NOMOS_0 x1T1R_NOMOS_0/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_1[0] x1T1R_NOMOS_1[0]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_1[1] x1T1R_NOMOS_1[1]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_1[2] x1T1R_NOMOS_1[2]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_2[0] x1T1R_NOMOS_2[0]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_2[1] x1T1R_NOMOS_2[1]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_2[2] x1T1R_NOMOS_2[2]/TOP_ELECTRODE x1T1R_NOMOS
Xx1T1R_NOMOS_2[3] x1T1R_NOMOS_2[3]/TOP_ELECTRODE x1T1R_NOMOS
Xx2T1R_w50_l500_0[0] x2T1R_w50_l500_0[0]/G_n x2T1R_w50_l500_0[0]/G_p x2T1R_w50_l500_0[0]/DIODE_p
+ x2T1R_w50_l500_0[0]/DIODE_n x2T1R_w50_l500_0[0]/B_n x2T1R_w50_l500_0[0]/B_p x2T1R_w50_l500_0[0]/D
+ VSUBS x2T1R_w50_l500
Xx2T1R_w50_l500_0[1] x2T1R_w50_l500_0[1]/G_n x2T1R_w50_l500_0[1]/G_p x2T1R_w50_l500_0[1]/DIODE_p
+ x2T1R_w50_l500_0[1]/DIODE_n x2T1R_w50_l500_0[1]/B_n x2T1R_w50_l500_0[1]/B_p x2T1R_w50_l500_0[1]/D
+ VSUBS x2T1R_w50_l500
Xx2T1R_w50_l500_0[2] x2T1R_w50_l500_0[2]/G_n x2T1R_w50_l500_0[2]/G_p x2T1R_w50_l500_0[2]/DIODE_p
+ x2T1R_w50_l500_0[2]/DIODE_n x2T1R_w50_l500_0[2]/B_n x2T1R_w50_l500_0[2]/B_p x2T1R_w50_l500_0[2]/D
+ VSUBS x2T1R_w50_l500
Xx1T1R_w50_l500_pmos_0[0] x1T1R_w50_l500_pmos_0[0]/B x1T1R_w50_l500_pmos_0[0]/D x1T1R_w50_l500_pmos_0[0]/DIODE
+ x1T1R_w50_l500_pmos
Xx1T1R_w50_l500_pmos_0[1] x1T1R_w50_l500_pmos_0[1]/B x1T1R_w50_l500_pmos_0[1]/D x1T1R_w50_l500_pmos_0[1]/DIODE
+ x1T1R_w50_l500_pmos
Xx1T1R_w50_l500_pmos_0[2] x1T1R_w50_l500_pmos_0[2]/B x1T1R_w50_l500_pmos_0[2]/D x1T1R_w50_l500_pmos_0[2]/DIODE
+ x1T1R_w50_l500_pmos
Xx2T1R_w50_l500_1[0] x2T1R_w50_l500_1[0]/G_n x2T1R_w50_l500_1[0]/G_p x2T1R_w50_l500_1[0]/DIODE_p
+ x2T1R_w50_l500_1[0]/DIODE_n x2T1R_w50_l500_1[0]/B_n x2T1R_w50_l500_1[0]/B_p x2T1R_w50_l500_1[0]/D
+ VSUBS x2T1R_w50_l500
Xx2T1R_w50_l500_1[1] x2T1R_w50_l500_1[1]/G_n x2T1R_w50_l500_1[1]/G_p x2T1R_w50_l500_1[1]/DIODE_p
+ x2T1R_w50_l500_1[1]/DIODE_n x2T1R_w50_l500_1[1]/B_n x2T1R_w50_l500_1[1]/B_p x2T1R_w50_l500_1[1]/D
+ VSUBS x2T1R_w50_l500
Xx2T1R_w50_l500_1[2] x2T1R_w50_l500_1[2]/G_n x2T1R_w50_l500_1[2]/G_p x2T1R_w50_l500_1[2]/DIODE_p
+ x2T1R_w50_l500_1[2]/DIODE_n x2T1R_w50_l500_1[2]/B_n x2T1R_w50_l500_1[2]/B_p x2T1R_w50_l500_1[2]/D
+ VSUBS x2T1R_w50_l500
Xx1T1R_w50_l700_nmos_0[0] x1T1R_w50_l700_nmos_0[0]/B x1T1R_w50_l700_nmos_0[0]/D x1T1R_w50_l700_nmos_0[0]/DIODE
+ VSUBS x1T1R_w50_l700_nmos
Xx1T1R_w50_l700_nmos_0[1] x1T1R_w50_l700_nmos_0[1]/B x1T1R_w50_l700_nmos_0[1]/D x1T1R_w50_l700_nmos_0[1]/DIODE
+ VSUBS x1T1R_w50_l700_nmos
Xx1T1R_w50_l700_nmos_0[2] x1T1R_w50_l700_nmos_0[2]/B x1T1R_w50_l700_nmos_0[2]/D x1T1R_w50_l700_nmos_0[2]/DIODE
+ VSUBS x1T1R_w50_l700_nmos
Xx1T1R_w50_l700_nmos_0[3] x1T1R_w50_l700_nmos_0[3]/B x1T1R_w50_l700_nmos_0[3]/D x1T1R_w50_l700_nmos_0[3]/DIODE
+ VSUBS x1T1R_w50_l700_nmos
Xx1T1R_w50_l500_pmos_1 x1T1R_w50_l500_pmos_1/B x1T1R_w50_l500_pmos_1/D x1T1R_w50_l500_pmos_1/DIODE
+ x1T1R_w50_l500_pmos
Xx1T1R_w50_l1000_nmos_0[0] x1T1R_w50_l1000_nmos_0[0]/B x1T1R_w50_l1000_nmos_0[0]/D
+ x1T1R_w50_l1000_nmos_0[0]/DIODE VSUBS x1T1R_w50_l1000_nmos
Xx1T1R_w50_l1000_nmos_0[1] x1T1R_w50_l1000_nmos_0[1]/B x1T1R_w50_l1000_nmos_0[1]/D
+ x1T1R_w50_l1000_nmos_0[1]/DIODE VSUBS x1T1R_w50_l1000_nmos
Xx1T1R_w50_l1000_nmos_0[2] x1T1R_w50_l1000_nmos_0[2]/B x1T1R_w50_l1000_nmos_0[2]/D
+ x1T1R_w50_l1000_nmos_0[2]/DIODE VSUBS x1T1R_w50_l1000_nmos
Xx1T1R_w50_l1000_nmos_0[3] x1T1R_w50_l1000_nmos_0[3]/B x1T1R_w50_l1000_nmos_0[3]/D
+ x1T1R_w50_l1000_nmos_0[3]/DIODE VSUBS x1T1R_w50_l1000_nmos
Xx1T1R_w50_l100_pmos_0 x1T1R_w50_l100_pmos_0/B x1T1R_w50_l100_pmos_0/D x1T1R_w50_l100_pmos_0/DIODE
+ x1T1R_w50_l100_pmos
Xx2T1R_w50_l100_0[0] x2T1R_w50_l100_0[0]/G_n x2T1R_w50_l100_0[0]/G_p x2T1R_w50_l100_0[0]/DIODE_p
+ x2T1R_w50_l100_0[0]/DIODE_n x2T1R_w50_l100_0[0]/B_n x2T1R_w50_l100_0[0]/B_p x2T1R_w50_l100_0[0]/D
+ VSUBS x2T1R_w50_l100
Xx2T1R_w50_l100_0[1] x2T1R_w50_l100_0[1]/G_n x2T1R_w50_l100_0[1]/G_p x2T1R_w50_l100_0[1]/DIODE_p
+ x2T1R_w50_l100_0[1]/DIODE_n x2T1R_w50_l100_0[1]/B_n x2T1R_w50_l100_0[1]/B_p x2T1R_w50_l100_0[1]/D
+ VSUBS x2T1R_w50_l100
Xx2T1R_w50_l100_0[2] x2T1R_w50_l100_0[2]/G_n x2T1R_w50_l100_0[2]/G_p x2T1R_w50_l100_0[2]/DIODE_p
+ x2T1R_w50_l100_0[2]/DIODE_n x2T1R_w50_l100_0[2]/B_n x2T1R_w50_l100_0[2]/B_p x2T1R_w50_l100_0[2]/D
+ VSUBS x2T1R_w50_l100
Xx1T1R_w50_l300_nmos_0 x1T1R_w50_l300_nmos_0/B x1T1R_w50_l300_nmos_0/D x1T1R_w50_l300_nmos_0/DIODE
+ VSUBS x1T1R_w50_l300_nmos
Xx1T1R_w50_l100_pmos_1[0] x1T1R_w50_l100_pmos_1[0]/B x1T1R_w50_l100_pmos_1[0]/D x1T1R_w50_l100_pmos_1[0]/DIODE
+ x1T1R_w50_l100_pmos
Xx1T1R_w50_l100_pmos_1[1] x1T1R_w50_l100_pmos_1[1]/B x1T1R_w50_l100_pmos_1[1]/D x1T1R_w50_l100_pmos_1[1]/DIODE
+ x1T1R_w50_l100_pmos
Xx1T1R_w50_l100_pmos_1[2] x1T1R_w50_l100_pmos_1[2]/B x1T1R_w50_l100_pmos_1[2]/D x1T1R_w50_l100_pmos_1[2]/DIODE
+ x1T1R_w50_l100_pmos
Xx1T1R_w50_l300_nmos_1[0] x1T1R_w50_l300_nmos_1[0]/B x1T1R_w50_l300_nmos_1[0]/D x1T1R_w50_l300_nmos_1[0]/DIODE
+ VSUBS x1T1R_w50_l300_nmos
Xx1T1R_w50_l300_nmos_1[1] x1T1R_w50_l300_nmos_1[1]/B x1T1R_w50_l300_nmos_1[1]/D x1T1R_w50_l300_nmos_1[1]/DIODE
+ VSUBS x1T1R_w50_l300_nmos
Xx1T1R_w50_l300_nmos_1[2] x1T1R_w50_l300_nmos_1[2]/B x1T1R_w50_l300_nmos_1[2]/D x1T1R_w50_l300_nmos_1[2]/DIODE
+ VSUBS x1T1R_w50_l300_nmos
Xx1T1R_w50_l300_nmos_1[3] x1T1R_w50_l300_nmos_1[3]/B x1T1R_w50_l300_nmos_1[3]/D x1T1R_w50_l300_nmos_1[3]/DIODE
+ VSUBS x1T1R_w50_l300_nmos
Xx2T1R_w50_l100_1[0] x2T1R_w50_l100_1[0]/G_n x2T1R_w50_l100_1[0]/G_p x2T1R_w50_l100_1[0]/DIODE_p
+ x2T1R_w50_l100_1[0]/DIODE_n x2T1R_w50_l100_1[0]/B_n x2T1R_w50_l100_1[0]/B_p x2T1R_w50_l100_1[0]/D
+ VSUBS x2T1R_w50_l100
Xx2T1R_w50_l100_1[1] x2T1R_w50_l100_1[1]/G_n x2T1R_w50_l100_1[1]/G_p x2T1R_w50_l100_1[1]/DIODE_p
+ x2T1R_w50_l100_1[1]/DIODE_n x2T1R_w50_l100_1[1]/B_n x2T1R_w50_l100_1[1]/B_p x2T1R_w50_l100_1[1]/D
+ VSUBS x2T1R_w50_l100
Xx2T1R_w50_l100_1[2] x2T1R_w50_l100_1[2]/G_n x2T1R_w50_l100_1[2]/G_p x2T1R_w50_l100_1[2]/DIODE_p
+ x2T1R_w50_l100_1[2]/DIODE_n x2T1R_w50_l100_1[2]/B_n x2T1R_w50_l100_1[2]/B_p x2T1R_w50_l100_1[2]/D
+ VSUBS x2T1R_w50_l100
Xx2T1R_w50_l700_0[0] x2T1R_w50_l700_0[0]/G_n x2T1R_w50_l700_0[0]/G_p x2T1R_w50_l700_0[0]/DIODE_p
+ x2T1R_w50_l700_0[0]/DIODE_n x2T1R_w50_l700_0[0]/B_n x2T1R_w50_l700_0[0]/B_p x2T1R_w50_l700_0[0]/D
+ VSUBS x2T1R_w50_l700
Xx2T1R_w50_l700_0[1] x2T1R_w50_l700_0[1]/G_n x2T1R_w50_l700_0[1]/G_p x2T1R_w50_l700_0[1]/DIODE_p
+ x2T1R_w50_l700_0[1]/DIODE_n x2T1R_w50_l700_0[1]/B_n x2T1R_w50_l700_0[1]/B_p x2T1R_w50_l700_0[1]/D
+ VSUBS x2T1R_w50_l700
Xx2T1R_w50_l700_0[2] x2T1R_w50_l700_0[2]/G_n x2T1R_w50_l700_0[2]/G_p x2T1R_w50_l700_0[2]/DIODE_p
+ x2T1R_w50_l700_0[2]/DIODE_n x2T1R_w50_l700_0[2]/B_n x2T1R_w50_l700_0[2]/B_p x2T1R_w50_l700_0[2]/D
+ VSUBS x2T1R_w50_l700
Xx2T1R_w50_l700_1[0] x2T1R_w50_l700_1[0]/G_n x2T1R_w50_l700_1[0]/G_p x2T1R_w50_l700_1[0]/DIODE_p
+ x2T1R_w50_l700_1[0]/DIODE_n x2T1R_w50_l700_1[0]/B_n x2T1R_w50_l700_1[0]/B_p x2T1R_w50_l700_1[0]/D
+ VSUBS x2T1R_w50_l700
Xx2T1R_w50_l700_1[1] x2T1R_w50_l700_1[1]/G_n x2T1R_w50_l700_1[1]/G_p x2T1R_w50_l700_1[1]/DIODE_p
+ x2T1R_w50_l700_1[1]/DIODE_n x2T1R_w50_l700_1[1]/B_n x2T1R_w50_l700_1[1]/B_p x2T1R_w50_l700_1[1]/D
+ VSUBS x2T1R_w50_l700
Xx2T1R_w50_l700_1[2] x2T1R_w50_l700_1[2]/G_n x2T1R_w50_l700_1[2]/G_p x2T1R_w50_l700_1[2]/DIODE_p
+ x2T1R_w50_l700_1[2]/DIODE_n x2T1R_w50_l700_1[2]/B_n x2T1R_w50_l700_1[2]/B_p x2T1R_w50_l700_1[2]/D
+ VSUBS x2T1R_w50_l700
Xx1T1R_w50_l700_pmos_0 x1T1R_w50_l700_pmos_0/B x1T1R_w50_l700_pmos_0/D x1T1R_w50_l700_pmos_0/DIODE
+ x1T1R_w50_l700_pmos
Xx1T1R_w50_l700_pmos_1[0] x1T1R_w50_l700_pmos_1[0]/B x1T1R_w50_l700_pmos_1[0]/D x1T1R_w50_l700_pmos_1[0]/DIODE
+ x1T1R_w50_l700_pmos
Xx1T1R_w50_l700_pmos_1[1] x1T1R_w50_l700_pmos_1[1]/B x1T1R_w50_l700_pmos_1[1]/D x1T1R_w50_l700_pmos_1[1]/DIODE
+ x1T1R_w50_l700_pmos
Xx1T1R_w50_l700_pmos_1[2] x1T1R_w50_l700_pmos_1[2]/B x1T1R_w50_l700_pmos_1[2]/D x1T1R_w50_l700_pmos_1[2]/DIODE
+ x1T1R_w50_l700_pmos
Xx1T1R_w50_l1000_pmos_0 x1T1R_w50_l1000_pmos_0/B x1T1R_w50_l1000_pmos_0/D x1T1R_w50_l1000_pmos_0/DIODE
+ x1T1R_w50_l1000_pmos
Xx1T1R_w50_l1000_pmos_1[0] x1T1R_w50_l1000_pmos_1[0]/B x1T1R_w50_l1000_pmos_1[0]/D
+ x1T1R_w50_l1000_pmos_1[0]/DIODE x1T1R_w50_l1000_pmos
Xx1T1R_w50_l1000_pmos_1[1] x1T1R_w50_l1000_pmos_1[1]/B x1T1R_w50_l1000_pmos_1[1]/D
+ x1T1R_w50_l1000_pmos_1[1]/DIODE x1T1R_w50_l1000_pmos
Xx1T1R_w50_l1000_pmos_1[2] x1T1R_w50_l1000_pmos_1[2]/B x1T1R_w50_l1000_pmos_1[2]/D
+ x1T1R_w50_l1000_pmos_1[2]/DIODE x1T1R_w50_l1000_pmos
.ends

.subckt nfet_01v8 pad_forty$6_0[1|4]/VSUBS
X0 a_19696_18954# a_18196_17178# a_18138_17266# pad_forty$6_0[1|4]/VSUBS sky130_fd_pr__nfet_01v8 ad=2.7e+11p pd=2.54e+06u as=2.32e+12p ps=1.658e+07u w=4.5e+06u l=1.7564e+08u
.ends

.subckt x/home/pi/NIST/Magic_layout/MPW6/HallMosfet/hall_mosfet
Xnfet_01v8_0 VSUBS nfet_01v8
.ends

.subckt NOISE_INJECTION$1 D[3] D[0] D[1] D[2] bias_out Noise_in VSS
X0 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=2.6712e+12p pd=3.288e+07u as=3.528e+11p ps=4.2e+06u w=420000u l=150000u
X1 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 bias_out a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X4 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X5 Noise_in a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X6 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 bias_out a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X8 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X9 Noise_in a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X10 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X16 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 bias_out a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X19 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 Noise_in a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X23 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 bias_out a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X29 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 Noise_in a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520167_1653520173$1 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1 a_147_525# a_200_252# w_0_0#
+ a_230_525#
X0 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt INV_B_13409687_0_1653520173$1 m1_430_56# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1_0/a_147_525#
+ PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1_0/w_0_0# m1_430_896# VSUBS
XNMOS_S_22639876_X1_Y1_1653520167_1653520173$1_0 VSUBS m1_430_896# m1_430_56# NMOS_S_22639876_X1_Y1_1653520167_1653520173$1
XPMOS_4T_48942251_X2_Y1_1653520168_1653520173$1_0 PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1_0/a_147_525#
+ m1_430_896# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1_0/w_0_0# m1_430_56# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4VD94C$1$1 c1_n1650_n792# m3_n1750_n820#
X0 c1_n1650_n792# m3_n1750_n820# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=1.6e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_RRZ644$1 c1_n842_n760# m3_n870_n788#
X0 c1_n842_n760# m3_n870_n788# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=8e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_F8PC2Z$1 m3_n550_n300# c1_n450_n220#
X0 c1_n450_n220# m3_n550_n300# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_FJFAMD$1 c1_n250_n200# m3_n291_n340#
X0 c1_n250_n200# m3_n291_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_K8PL49$1$1 c1_n442_n400# m3_n470_n428#
X0 c1_n442_n400# m3_n470_n428# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4CW8F2$1 c1_n842_n376# m3_n870_n410#
X0 c1_n842_n376# m3_n870_n410# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=8e+06u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520174$1 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_DAC$1 RST VOUT D1 D4 D3 D5 D2 D0 VPWR m4_656_641# VGND
XINV_B_13409687_0_1653520173$1_2 m1_3830_5595# VPWR VPWR D4 VGND INV_B_13409687_0_1653520173$1
XINV_B_13409687_0_1653520173$1_3 m1_2470_5595# VPWR VPWR D5 VGND INV_B_13409687_0_1653520173$1
XINV_B_13409687_0_1653520173$1_4 m1_2436_3089# VPWR VPWR D2 VGND INV_B_13409687_0_1653520173$1
XINV_B_13409687_0_1653520173$1_5 m1_3824_2469# VPWR VPWR D1 VGND INV_B_13409687_0_1653520173$1
Xsky130_fd_pr__cap_mim_m3_1_4VD94C$1$1_0 VOUT m1_2470_5595# sky130_fd_pr__cap_mim_m3_1_4VD94C$1$1
XC8_8 VOUT m1_3830_5595# sky130_fd_pr__cap_mim_m3_1_RRZ644$1
XC4_2 m1_3824_2469# VOUT sky130_fd_pr__cap_mim_m3_1_F8PC2Z$1
Xsky130_fd_pr__cap_mim_m3_1_FJFAMD$1_0 VOUT m1_2452_2549# sky130_fd_pr__cap_mim_m3_1_FJFAMD$1
XC4_4 VOUT m1_2436_3089# sky130_fd_pr__cap_mim_m3_1_K8PL49$1$1
XC2_2 VOUT VGND sky130_fd_pr__cap_mim_m3_1_FJFAMD$1
Xsky130_fd_pr__cap_mim_m3_1_4CW8F2$1_0 VOUT m1_3830_3805# sky130_fd_pr__cap_mim_m3_1_4CW8F2$1
XNMOS_S_22639876_X1_Y1_1653520174$1_0 VGND RST VOUT NMOS_S_22639876_X1_Y1_1653520174$1
XINV_B_13409687_0_1653520173$1_0 m1_2452_2549# VPWR VPWR D0 VGND INV_B_13409687_0_1653520173$1
XINV_B_13409687_0_1653520173$1_1 m1_3830_3805# VPWR VPWR D3 VGND INV_B_13409687_0_1653520173$1
.ends

.subckt DAC_NOISE VSUBS
XNOISE_INJECTION$1_0 NOISE_INJECTION$1_0/D[3] NOISE_INJECTION$1_0/D[0] NOISE_INJECTION$1_0/D[1]
+ NOISE_INJECTION$1_0/D[2] NOISE_INJECTION$1_0/bias_out NOISE_INJECTION$1_0/Noise_in
+ VSUBS NOISE_INJECTION$1
XDCDC_DAC$1_0 DCDC_DAC$1_0/RST DCDC_DAC$1_0/VOUT DCDC_DAC$1_0/D1 DCDC_DAC$1_0/D4 DCDC_DAC$1_0/D3
+ DCDC_DAC$1_0/D5 DCDC_DAC$1_0/D2 DCDC_DAC$1_0/D0 DCDC_DAC$1_0/VPWR m4_18449_8000#
+ VSUBS DCDC_DAC$1
.ends

.subckt single_RRAM_Array
.ends

.subckt X1$1 w_n5371_n1923# a_n5223_n127# a_n5223_n1785# a_n5249_n1727#
X0 a_n5223_n127# a_n5249_n1727# a_n5223_n1785# w_n5371_n1923# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X4$1 a_n5074_164# a_n5248_n1596# a_n5074_n1494# a_n5162_n1436#
X0 a_n5074_164# a_n5162_n1436# a_n5074_n1494# a_n5248_n1596# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pad$1$1 single_pad$4$1_0[0|1]/m1_n4000_4006# single_pad$4$1_0[3|0]/m1_n4000_4006#
+ single_pad$4$1_0[0|0]/m1_n4000_4006# single_pad$4$1_0[2|1]/m1_n4000_4006# single_pad$4$1_0[2|0]/m1_n4000_4006#
+ single_pad$4$1_0[1|1]/m1_n4000_4006# single_pad$4$1_0[1|0]/m1_n4000_4006# single_pad$4$1_0[3|1]/m1_n4000_4006#
.ends

.subckt X7$1 a_n7416_n4222# a_n7330_n4062# a_n7242_n4120# a_n7242_n2462#
X0 a_n7242_n2462# a_n7330_n4062# a_n7242_n4120# a_n7416_n4222# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X0$1 a_n5109_n1805# a_n5135_n1747# w_n5257_n1943# a_n5109_n147#
X0 a_n5109_n147# a_n5135_n1747# a_n5109_n1805# w_n5257_n1943# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X3$1 a_n5022_n1696# a_n5022_n38# a_n5196_n1798# a_n5110_n1638#
X0 a_n5022_n38# a_n5110_n1638# a_n5022_n1696# a_n5196_n1798# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X6$1 a_n7694_n2470# a_n7694_n4128# a_n7868_n4230# a_n7782_n4070#
X0 a_n7694_n2470# a_n7782_n4070# a_n7694_n4128# a_n7868_n4230# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X2$1 a_n5254_n1836# a_n5168_n1676# a_n5080_n1734# a_n5080_n76#
X0 a_n5080_n76# a_n5168_n1676# a_n5080_n1734# a_n5254_n1836# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X5$1 a_n5018_n1474# a_n5018_184# a_n5192_n1576# a_n5106_n1416#
X0 a_n5018_184# a_n5106_n1416# a_n5018_n1474# a_n5192_n1576# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pseudo_resistor_s8  Vin Vdd  Vcontrol2  v1 v2  Vcontrol1  Vout vgnd
XX1$1_0  Vout  Vout m1_n7863_n1622# v2 X1$1
XX4$1_0 vgnd vgnd  v1  Vcontrol1 X4$1
Xpad$1$1_0 v2  Vcontrol1 vgnd m1_n8466_31# m1_n12430_4307#  v1  Vcontrol2  Vout pad$1$1
XX7$1_0 vgnd  Vcontrol2 v2 vgnd X7$1
XX0$1_0 m1_n7863_n1622#  v1 m1_n8466_31# m1_n8466_31# X0$1
XX3$1_0 m1_n12430_4307# v2 vgnd  Vout X3$1
XX6$1_0 vgnd v2 vgnd  Vcontrol1 X6$1
XX2$1_0 vgnd m1_n8466_31# m1_n12430_4307#  v1 X2$1
XX5$1_0  v1 vgnd vgnd  Vcontrol2 X5$1
.ends

.subckt pseudoResistorS8Array VSUBS
Xpseudo_resistor_s8_0[0] pseudo_resistor_s8_0[0]/ Vin pseudo_resistor_s8_0[0]/Vdd
+ pseudo_resistor_s8_0[0]/ Vcontrol2 pseudo_resistor_s8_0[0]/ v1 pseudo_resistor_s8_0[0]/v2
+ pseudo_resistor_s8_0[0]/ Vcontrol1 pseudo_resistor_s8_0[0]/ Vout VSUBS pseudo_resistor_s8
Xpseudo_resistor_s8_0[1] pseudo_resistor_s8_0[1]/ Vin pseudo_resistor_s8_0[1]/Vdd
+ pseudo_resistor_s8_0[1]/ Vcontrol2 pseudo_resistor_s8_0[1]/ v1 pseudo_resistor_s8_0[1]/v2
+ pseudo_resistor_s8_0[1]/ Vcontrol1 pseudo_resistor_s8_0[1]/ Vout VSUBS pseudo_resistor_s8
Xpseudo_resistor_s8_0[2] pseudo_resistor_s8_0[2]/ Vin pseudo_resistor_s8_0[2]/Vdd
+ pseudo_resistor_s8_0[2]/ Vcontrol2 pseudo_resistor_s8_0[2]/ v1 pseudo_resistor_s8_0[2]/v2
+ pseudo_resistor_s8_0[2]/ Vcontrol1 pseudo_resistor_s8_0[2]/ Vout VSUBS pseudo_resistor_s8
Xpseudo_resistor_s8_0[3] pseudo_resistor_s8_0[3]/ Vin pseudo_resistor_s8_0[3]/Vdd
+ pseudo_resistor_s8_0[3]/ Vcontrol2 pseudo_resistor_s8_0[3]/ v1 pseudo_resistor_s8_0[3]/v2
+ pseudo_resistor_s8_0[3]/ Vcontrol1 pseudo_resistor_s8_0[3]/ Vout VSUBS pseudo_resistor_s8
.ends

.subckt sky130_fd_pr__pfet_01v8$1 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226#
X0 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pmos_l8u G Vdd D
Xpmos D G m1_n259_333# m1_n259_333# sky130_fd_pr__pfet_01v8$1
.ends

.subckt singlePmosArray
Xpmos_l8u_0[0] pmos_l8u_0[0]/G pmos_l8u_0[0]/Vdd pmos_l8u_0[0]/D pmos_l8u
Xpmos_l8u_0[1] pmos_l8u_0[1]/G pmos_l8u_0[1]/Vdd pmos_l8u_0[1]/D pmos_l8u
Xpmos_l8u_0[2] pmos_l8u_0[2]/G pmos_l8u_0[2]/Vdd pmos_l8u_0[2]/D pmos_l8u
Xpmos_l8u_0[3] pmos_l8u_0[3]/G pmos_l8u_0[3]/Vdd pmos_l8u_0[3]/D pmos_l8u
Xpmos_l8u_0[4] pmos_l8u_0[4]/G pmos_l8u_0[4]/Vdd pmos_l8u_0[4]/D pmos_l8u
.ends

.subckt sky130_fd_pr__nfet_01v8_ZZXZ62 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185#
X0 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt nmos_l8u$1 nmos/a_n858_n73# nmos/a_n800_n99# nmos/a_800_n73# VSUBS
Xnmos nmos/a_800_n73# nmos/a_n800_n99# nmos/a_n858_n73# VSUBS sky130_fd_pr__nfet_01v8_ZZXZ62
.ends

.subckt sky130_fd_pr__pfet_01v8 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226#
X0 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pmos_l8u$1 pmos/w_n996_n226# pmos/a_n800_n104# pmos/a_800_n78# pmos/a_n858_n78#
Xpmos pmos/a_800_n78# pmos/a_n800_n104# pmos/a_n858_n78# pmos/w_n996_n226# sky130_fd_pr__pfet_01v8
.ends

.subckt pad$1$1$1 single_pad$4$1$1_0[0|1]/m1_n4000_4006# single_pad$4$1$1_0[0|0]/m1_n4000_4006#
+ single_pad$4$1$1_0[2|1]/m1_n4000_4006# single_pad$4$1$1_0[2|0]/m1_n4000_4006# single_pad$4$1$1_0[1|1]/m1_n4000_4006#
+ single_pad$4$1$1_0[1|0]/m1_n4000_4006#
.ends

.subckt pseudo_resistor_d4 Vcontrol1 Vcontrol3 vgnd Vin Vout Vcontrol2 VSUBS
Xnmos_l8u$1_0 VSUBS Vcontrol1 m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_1 VSUBS Vcontrol1 m1_91_n1395# VSUBS nmos_l8u$1
Xnmos_l8u$1_2 VSUBS m1_3611_n510# m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_3 VSUBS m1_2677_208# m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_4 VSUBS m1_3611_n510# m1_91_n1395# VSUBS nmos_l8u$1
Xnmos_l8u$1_5 VSUBS m1_2677_208# m1_91_n1395# VSUBS nmos_l8u$1
Xpmos_l8u$1_1 m1_n107_n1055# m1_91_n1395# m1_n107_n1055# m1_91_n1395# pmos_l8u$1
Xpmos_l8u$1_0 Vin m1_91_n2147# Vin m1_91_n2147# pmos_l8u$1
Xpmos_l8u$1_2 Vin m1_91_n1395# m1_1753_n647# Vin pmos_l8u$1
Xpmos_l8u$1_3 m1_n107_n1055# m1_91_n2147# m1_1753_n647# m1_n107_n1055# pmos_l8u$1
Xpad$1$1$1_0 Vcontrol1 VSUBS m1_2677_208# Vin m1_3611_n510# m1_n107_n1055# pad$1$1$1
.ends

.subckt pseudoResistorD4Array VSUBS
Xpseudo_resistor_d4_0[0] pseudo_resistor_d4_0[0]/Vcontrol1 pseudo_resistor_d4_0[0]/Vcontrol3
+ pseudo_resistor_d4_0[0]/vgnd pseudo_resistor_d4_0[0]/Vin pseudo_resistor_d4_0[0]/Vout
+ pseudo_resistor_d4_0[0]/Vcontrol2 VSUBS pseudo_resistor_d4
Xpseudo_resistor_d4_0[1] pseudo_resistor_d4_0[1]/Vcontrol1 pseudo_resistor_d4_0[1]/Vcontrol3
+ pseudo_resistor_d4_0[1]/vgnd pseudo_resistor_d4_0[1]/Vin pseudo_resistor_d4_0[1]/Vout
+ pseudo_resistor_d4_0[1]/Vcontrol2 VSUBS pseudo_resistor_d4
Xpseudo_resistor_d4_0[2] pseudo_resistor_d4_0[2]/Vcontrol1 pseudo_resistor_d4_0[2]/Vcontrol3
+ pseudo_resistor_d4_0[2]/vgnd pseudo_resistor_d4_0[2]/Vin pseudo_resistor_d4_0[2]/Vout
+ pseudo_resistor_d4_0[2]/Vcontrol2 VSUBS pseudo_resistor_d4
Xpseudo_resistor_d4_0[3] pseudo_resistor_d4_0[3]/Vcontrol1 pseudo_resistor_d4_0[3]/Vcontrol3
+ pseudo_resistor_d4_0[3]/vgnd pseudo_resistor_d4_0[3]/Vin pseudo_resistor_d4_0[3]/Vout
+ pseudo_resistor_d4_0[3]/Vcontrol2 VSUBS pseudo_resistor_d4
.ends

.subckt tie_down w_5419_n25463#
D0 a_5317_n25565# w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt pad single_pad$3_0[0|1]/m1_n12006_n4000# single_pad$3_0[2|0]/m1_n12006_n4000#
+ single_pad$3_0[1|0]/m1_n12006_n4000# single_pad$3_0[4|1]/m1_n12006_n4000# single_pad$3_0[0|0]/m1_n12006_n4000#
+ single_pad$3_0[3|1]/m1_n12006_n4000# single_pad$3_0[2|1]/m1_n12006_n4000# single_pad$3_0[4|0]/m1_n12006_n4000#
+ single_pad$3_0[3|0]/m1_n12006_n4000# single_pad$3_0[1|1]/m1_n12006_n4000#
.ends

.subckt RRAM_bridge Vb_2 vgnd DIODE_2 DIODE_1 Vdd D_2 Vb_1 D_1 G_2 G_1 TE pad_0/VSUBS
Xtie_down_0 a_26470_n17436# tie_down
Xtie_down_1 a_26470_n57# tie_down
Xpad_0 a_26470_n57# Vb_1 TE pad_0/VSUBS a_26470_n17436# a_26470_n17436# a_14718_n17285#
+ a_26570_n17410# TE a_26470_n57# pad
X0 a_26570_n17410# a_26470_n17436# TE pad_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=4.06e+12p ps=2.916e+07u w=7e+06u l=500000u
X1 a_14718_n17285# TE pad_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X2 Vb_1 a_26470_n57# TE pad_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=0p ps=0u w=7e+06u l=500000u
X3 a_14718_n17285# TE pad_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
.ends

.subckt RRAM_bridgeArray VSUBS
XRRAM_bridge_0 RRAM_bridge_0/Vb_2 RRAM_bridge_0/vgnd RRAM_bridge_0/DIODE_2 RRAM_bridge_0/DIODE_1
+ RRAM_bridge_0/Vdd RRAM_bridge_0/D_2 RRAM_bridge_0/Vb_1 RRAM_bridge_0/D_1 RRAM_bridge_0/G_2
+ RRAM_bridge_0/G_1 RRAM_bridge_0/TE VSUBS RRAM_bridge
XRRAM_bridge_1 RRAM_bridge_1/Vb_2 RRAM_bridge_1/vgnd RRAM_bridge_1/DIODE_2 RRAM_bridge_1/DIODE_1
+ RRAM_bridge_1/Vdd RRAM_bridge_1/D_2 RRAM_bridge_1/Vb_1 RRAM_bridge_1/D_1 RRAM_bridge_1/G_2
+ RRAM_bridge_1/G_1 RRAM_bridge_1/TE VSUBS RRAM_bridge
XRRAM_bridge_2 RRAM_bridge_2/Vb_2 RRAM_bridge_2/vgnd RRAM_bridge_2/DIODE_2 RRAM_bridge_2/DIODE_1
+ RRAM_bridge_2/Vdd RRAM_bridge_2/D_2 RRAM_bridge_2/Vb_1 RRAM_bridge_2/D_1 RRAM_bridge_2/G_2
+ RRAM_bridge_2/G_1 RRAM_bridge_2/TE VSUBS RRAM_bridge
.ends

.subckt X2$1$1 a_n5254_n1836# a_n5168_n1676# a_n5080_n1734# a_n5080_n76#
X0 a_n5080_n76# a_n5168_n1676# a_n5080_n1734# a_n5254_n1836# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X1$1$1 w_n5371_n1923# a_n5223_n127# a_n5223_n1785# a_n5249_n1727#
X0 a_n5223_n127# a_n5249_n1727# a_n5223_n1785# w_n5371_n1923# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X0$1$1 a_n5109_n1805# a_n5135_n1747# w_n5257_n1943# a_n5109_n147#
X0 a_n5109_n147# a_n5135_n1747# a_n5109_n1805# w_n5257_n1943# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X7$1$1 a_n7416_n4222# a_n7330_n4062# a_n7242_n4120# a_n7242_n2462#
X0 a_n7242_n2462# a_n7330_n4062# a_n7242_n4120# a_n7416_n4222# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pad$1$1$1$1 single_pad$4$1$1$1_0[2|1]/m1_n4000_4006# single_pad$4$1$1$1_0[2|0]/m1_n4000_4006#
+ single_pad$4$1$1$1_0[1|1]/m1_n4000_4006# single_pad$4$1$1$1_0[1|0]/m1_n4000_4006#
+ single_pad$4$1$1$1_0[0|1]/m1_n4000_4006# single_pad$4$1$1$1_0[0|0]/m1_n4000_4006#
.ends

.subckt X6$1$1 a_n7694_n2470# a_n7694_n4128# a_n7868_n4230# a_n7782_n4070#
X0 a_n7694_n2470# a_n7782_n4070# a_n7694_n4128# a_n7868_n4230# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X5$1$1 a_n5018_n1474# a_n5018_184# a_n5192_n1576# a_n5106_n1416#
X0 a_n5018_184# a_n5106_n1416# a_n5018_n1474# a_n5192_n1576# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X4$1$1 a_n5074_164# a_n5248_n1596# a_n5074_n1494# a_n5162_n1436#
X0 a_n5074_164# a_n5162_n1436# a_n5074_n1494# a_n5248_n1596# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X3$1$1 a_n5022_n1696# a_n5022_n38# a_n5196_n1798# a_n5110_n1638#
X0 a_n5022_n38# a_n5110_n1638# a_n5022_n1696# a_n5196_n1798# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pseudo_resistor_s8_6Pins Vdd  Vcontrol1  Vout  Vcontrol2  Vin vgnd
XX2$1$1_0 vgnd m1_n8466_31# m1_n8949_n1612# m1_n8379_n214# X2$1$1
XX1$1$1_0  Vout  Vout m1_n7863_n1622# m1_n8950_n337# X1$1$1
XX0$1$1_0 m1_n7863_n1622# m1_n8379_n214# m1_n8466_31# m1_n8466_31# X0$1$1
XX7$1$1_0 vgnd  Vcontrol2 m1_n8950_n337# vgnd X7$1$1
Xpad$1$1$1$1_0  Vout  Vcontrol1 m1_n8466_31# m1_n8949_n1612# vgnd  Vcontrol2 pad$1$1$1$1
XX6$1$1_0 vgnd m1_n8950_n337# vgnd  Vcontrol1 X6$1$1
XX5$1$1_0 m1_n8379_n214# vgnd vgnd  Vcontrol2 X5$1$1
XX4$1$1_0 vgnd vgnd m1_n8379_n214#  Vcontrol1 X4$1$1
XX3$1$1_0 m1_n8949_n1612# m1_n8950_n337# vgnd  Vout X3$1$1
.ends

.subckt pseudoResistorS8_6PinArray VSUBS
Xpseudo_resistor_s8_6Pins_0[0] pseudo_resistor_s8_6Pins_0[0]/Vdd pseudo_resistor_s8_6Pins_0[0]/ Vcontrol1
+ pseudo_resistor_s8_6Pins_0[0]/ Vout pseudo_resistor_s8_6Pins_0[0]/ Vcontrol2 pseudo_resistor_s8_6Pins_0[0]/ Vin
+ VSUBS pseudo_resistor_s8_6Pins
Xpseudo_resistor_s8_6Pins_0[1] pseudo_resistor_s8_6Pins_0[1]/Vdd pseudo_resistor_s8_6Pins_0[1]/ Vcontrol1
+ pseudo_resistor_s8_6Pins_0[1]/ Vout pseudo_resistor_s8_6Pins_0[1]/ Vcontrol2 pseudo_resistor_s8_6Pins_0[1]/ Vin
+ VSUBS pseudo_resistor_s8_6Pins
Xpseudo_resistor_s8_6Pins_0[2] pseudo_resistor_s8_6Pins_0[2]/Vdd pseudo_resistor_s8_6Pins_0[2]/ Vcontrol1
+ pseudo_resistor_s8_6Pins_0[2]/ Vout pseudo_resistor_s8_6Pins_0[2]/ Vcontrol2 pseudo_resistor_s8_6Pins_0[2]/ Vin
+ VSUBS pseudo_resistor_s8_6Pins
Xpseudo_resistor_s8_6Pins_0[3] pseudo_resistor_s8_6Pins_0[3]/Vdd pseudo_resistor_s8_6Pins_0[3]/ Vcontrol1
+ pseudo_resistor_s8_6Pins_0[3]/ Vout pseudo_resistor_s8_6Pins_0[3]/ Vcontrol2 pseudo_resistor_s8_6Pins_0[3]/ Vin
+ VSUBS pseudo_resistor_s8_6Pins
.ends

.subckt sky130_fd_pr__nfet_01v8$1 a_143_69# a_n17_n17# a_1743_95# a_85_95#
X0 a_1743_95# a_143_69# a_85_95# a_n17_n17# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt nmos_l8u G D vgnd VSUBS
Xsky130_fd_pr__nfet_01v8$1_0 G VSUBS D VSUBS sky130_fd_pr__nfet_01v8$1
.ends

.subckt singleNmosArray VSUBS
Xnmos_l8u_0[0] nmos_l8u_0[0]/G nmos_l8u_0[0]/D nmos_l8u_0[0]/vgnd VSUBS nmos_l8u
Xnmos_l8u_0[1] nmos_l8u_0[1]/G nmos_l8u_0[1]/D nmos_l8u_0[1]/vgnd VSUBS nmos_l8u
Xnmos_l8u_0[2] nmos_l8u_0[2]/G nmos_l8u_0[2]/D nmos_l8u_0[2]/vgnd VSUBS nmos_l8u
Xnmos_l8u_0[3] nmos_l8u_0[3]/G nmos_l8u_0[3]/D nmos_l8u_0[3]/vgnd VSUBS nmos_l8u
Xnmos_l8u_0[4] nmos_l8u_0[4]/G nmos_l8u_0[4]/D nmos_l8u_0[4]/vgnd VSUBS nmos_l8u
.ends

.subckt sky130_fd_pr__pfet_01v8_DJNEY9 a_400_n364# w_n596_n584# a_n458_n364# a_n400_n461#
X0 a_400_n364# a_n400_n461# a_n458_n364# w_n596_n584# sky130_fd_pr__pfet_01v8 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=4e+06u
.ends

.subckt pmos_l4u pmos_l4u/a_n458_n364# pmos_l4u/a_400_n364# pmos_l4u/a_n400_n461#
+ pmos_l4u/w_n596_n584#
Xpmos_l4u pmos_l4u/a_400_n364# pmos_l4u/w_n596_n584# pmos_l4u/a_n458_n364# pmos_l4u/a_n400_n461#
+ sky130_fd_pr__pfet_01v8_DJNEY9
.ends

.subckt pseudo_resistor_d1 Vin Vout Vb
Xpmos_l4u_0 Vin m1_186_558# Vb Vin pmos_l4u
Xpmos_l4u_1 m1_186_558# Vout Vb Vout pmos_l4u
.ends

.subckt pseudoResistorD1Array
Xpseudo_resistor_d1_0[0] pseudo_resistor_d1_0[0]/Vin pseudo_resistor_d1_0[0]/Vout
+ pseudo_resistor_d1_0[0]/Vb pseudo_resistor_d1
Xpseudo_resistor_d1_0[1] pseudo_resistor_d1_0[1]/Vin pseudo_resistor_d1_0[1]/Vout
+ pseudo_resistor_d1_0[1]/Vb pseudo_resistor_d1
Xpseudo_resistor_d1_0[2] pseudo_resistor_d1_0[2]/Vin pseudo_resistor_d1_0[2]/Vout
+ pseudo_resistor_d1_0[2]/Vb pseudo_resistor_d1
Xpseudo_resistor_d1_0[3] pseudo_resistor_d1_0[3]/Vin pseudo_resistor_d1_0[3]/Vout
+ pseudo_resistor_d1_0[3]/Vb pseudo_resistor_d1
Xpseudo_resistor_d1_0[4] pseudo_resistor_d1_0[4]/Vin pseudo_resistor_d1_0[4]/Vout
+ pseudo_resistor_d1_0[4]/Vb pseudo_resistor_d1
.ends

.subckt GWU_Adamlab VSUBS
Xsingle_RRAM_Array_0 single_RRAM_Array
XpseudoResistorS8Array_0 VSUBS pseudoResistorS8Array
XsinglePmosArray_0 singlePmosArray
XpseudoResistorD4Array_0 VSUBS pseudoResistorD4Array
XpseudoResistorD4Array_1 VSUBS pseudoResistorD4Array
XRRAM_bridgeArray_0 VSUBS RRAM_bridgeArray
XpseudoResistorS8_6PinArray_0 VSUBS pseudoResistorS8_6PinArray
XsingleNmosArray_0 VSUBS singleNmosArray
XpseudoResistorD1Array_0 pseudoResistorD1Array
.ends

.subckt pdiff
.ends

.subckt ndiff
.ends

.subckt poly
.ends

.subckt pwell
.ends

.subckt n+poly
R0 a_40100_43000# a_74100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=1.545e+08u
R1 a_6000_27000# a_12000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=1.35e+07u
R2 a_12000_75000# a_24000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R3 a_12000_27000# a_22000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=3.35e+07u
R4 a_0_75000# a_12000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R5 a_60000_75000# a_72000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R6 a_2000_27000# a_2000_27000# sky130_fd_pr__res_generic_po w=1e+06u l=1.05e+07u
R7 a_2000_27000# a_6000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=3.5e+06u
R8 a_24000_75000# a_36000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R9 a_40000_11000# a_74000_11000# sky130_fd_pr__res_generic_po w=7.5e+06u l=1.535e+08u
R10 a_72000_75000# a_72000_75000# sky130_fd_pr__res_generic_po w=1e+06u l=4.05e+07u
R11 a_22000_27000# a_40000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=7.35e+07u
R12 a_74000_27000# a_74000_27000# sky130_fd_pr__res_generic_po w=1e+06u l=3.05e+07u
R13 a_6100_43000# a_12100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=1.45e+07u
R14 a_12100_59000# a_24100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R15 a_12100_90000# a_24100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R16 a_36000_75000# a_48000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R17 a_2100_43000# a_2100_43000# sky130_fd_pr__res_generic_po w=5e+06u l=1.55e+07u
R18 a_12100_43000# a_22100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=3.45e+07u
R19 a_0_59000# a_12100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R20 a_60100_59000# a_72100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R21 a_2100_43000# a_6100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.5e+06u
R22 a_0_90000# a_12100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R23 a_60100_90000# a_72100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R24 a_24100_59000# a_36100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R25 a_24100_90000# a_36100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R26 a_48000_75000# a_60000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R27 a_74100_43000# a_74100_43000# sky130_fd_pr__res_generic_po w=5e+06u l=3.55e+07u
R28 a_6000_11000# a_12000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=1.35e+07u
R29 a_72100_59000# a_72100_59000# sky130_fd_pr__res_generic_po w=5e+06u l=4.55e+07u
R30 a_22100_43000# a_40100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=7.45e+07u
R31 a_74000_11000# a_74000_11000# sky130_fd_pr__res_generic_po w=250000u l=3.025e+07u
R32 a_72100_90000# a_72100_90000# sky130_fd_pr__res_generic_po w=2e+07u l=6.05e+07u
R33 a_12000_11000# a_22000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=3.35e+07u
R34 a_2000_11000# a_2000_11000# sky130_fd_pr__res_generic_po w=750000u l=1.025e+07u
R35 a_2000_11000# a_6000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=3.5e+06u
R36 a_36100_59000# a_48100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R37 a_36100_90000# a_48100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R38 a_40000_27000# a_74000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=1.535e+08u
R39 a_22000_11000# a_40000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=7.35e+07u
R40 a_48100_59000# a_60100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R41 a_48100_90000# a_60100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
.ends

.subckt nwell
.ends

.subckt user_analog_project_wrapper wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2] wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6]
+ wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11]
+ wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[1]
+ wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[1] wbs_dat_o[2] wbs_dat_o[3]
+ wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0]
+ wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i wbs_dat_i[17] wbs_dat_i[18]
+ wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23]
+ wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29]
+ wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30] wbs_adr_i[31] la_oenb[2] wbs_dat_o[17]
+ wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22]
+ wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28]
+ wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31] la_oenb[5] la_data_in[0] la_data_in[1]
+ la_data_in[2] la_data_in[3] la_data_in[4] la_data_in[5] la_data_out[0] la_data_out[1]
+ la_data_out[2] la_data_out[3] la_data_out[4] la_data_out[5] la_data_in[23] la_data_in[24]
+ la_data_in[25] la_oenb[6] la_oenb[7] la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11]
+ la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8]
+ la_data_in[9] la_data_in[15] la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13]
+ la_data_out[14] la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18]
+ la_data_out[19] la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23]
+ la_data_out[24] la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10]
+ la_data_out[6] la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10]
+ la_oenb[11] la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17]
+ la_oenb[18] la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23]
+ la_oenb[24] la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40]
+ la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30]
+ la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35]
+ la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40]
+ la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45]
+ la_data_out[46] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46]
+ la_oenb[38] la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43]
+ la_data_in[27] la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31]
+ la_data_in[32] la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37]
+ la_oenb[26] la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31]
+ la_oenb[32] la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48]
+ la_oenb[49] la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55]
+ la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62]
+ la_oenb[63] la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] gpio_analog[2] gpio_analog[3]
+ gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4]
+ gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1] io_analog[2] io_analog[3]
+ io_analog[4] io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12] io_out[13]
+ io_out[9] vccd1 vdda1 vssa1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10] io_analog[5]
+ io_analog[6] io_analog[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17]
+ io_analog[8] io_analog[9] gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17]
+ gpio_noesd[8] io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14]
+ io_out[15] io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2
+ gpio_analog[7] gpio_analog[8] io_in[14] io_in[15] vssa2 io_in_3v3[24] io_in_3v3[25]
+ io_in_3v3[26] gpio_analog[16] gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11]
+ io_in[18] io_in[19] io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21]
+ io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24]
+ io_in[25] io_in[26] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15]
+ io_out[18] io_out[19] io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25]
+ io_out[26] gpio_noesd[16] gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15]
+ io_in_3v3[18] io_in_3v3[19] vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ vssd2 io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2]
+ io_in[3] io_in[4] io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0]
+ io_oeb[1] io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7]
+ io_out[8] gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5]
+ io_out[0]
XBIG_PMOS_4 BIG_PMOS
XPMU_0 PMU_0/VSUBS PMU
X1T1R_2T1R_nmos_pmos_0 DAC_NOISE_3/VSUBS x1T1R_2T1R_nmos_pmos
XBIG_PMOS_5 BIG_PMOS
XBIG_PMOS_6 BIG_PMOS
XBIG_PMOS_7 BIG_PMOS
X/home/pi/NIST/Magic_layout/MPW6/HallMosfet/hall_mosfet_0 x/home/pi/NIST/Magic_layout/MPW6/HallMosfet/hall_mosfet
X/home/pi/NIST/Magic_layout/MPW6/HallMosfet/hall_mosfet_1 x/home/pi/NIST/Magic_layout/MPW6/HallMosfet/hall_mosfet
XDAC_NOISE_0 PMU_0/VSUBS DAC_NOISE
XDAC_NOISE_1 PMU_0/VSUBS DAC_NOISE
XDAC_NOISE_2 PMU_0/VSUBS DAC_NOISE
XDAC_NOISE_3 DAC_NOISE_3/VSUBS DAC_NOISE
XGWU_Adamlab_0 PMU_0/VSUBS GWU_Adamlab
Xpdiff_0 pdiff
Xndiff_0 ndiff
Xpoly_0 poly
Xpwell_0 pwell
XBIG_PMOS_0 BIG_PMOS
XBIG_PMOS_1 BIG_PMOS
XBIG_PMOS_2 BIG_PMOS
Xn+poly_0 n+poly
XBIG_PMOS_3 BIG_PMOS
Xnwell_0 nwell
.ends
